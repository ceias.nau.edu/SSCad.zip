ISO-10303-21;
HEADER;
FILE_DESCRIPTION(('STEP AP214'),'2;1');
FILE_NAME('part.step','',(''),(''),'','','');
FILE_SCHEMA(('AUTOMOTIVE_DESIGN { 1 0 10303 214 1 1 1 1 }'));
ENDSEC;
DATA;
#1=APPLICATION_CONTEXT('core data for automotive mechanical design processes');
#2=APPLICATION_PROTOCOL_DEFINITION('international standard','automotive_design',2000,#1);
#3=PRODUCT_CONTEXT('',#1,'mechanical');
#4=PRODUCT('Part','Part','',(#3));
#5=PRODUCT_RELATED_PRODUCT_CATEGORY('part','',(#4));
#6=PRODUCT_DEFINITION_FORMATION('','',#4);
#7=PRODUCT_DEFINITION_CONTEXT('part definition',#1,'design');
#8=PRODUCT_DEFINITION('design','',#6,#7);
#9=PRODUCT_DEFINITION_SHAPE('','',#8);
#10=(LENGTH_UNIT() NAMED_UNIT(*) SI_UNIT(.MILLI.,.METRE.));
#11=(NAMED_UNIT(*) PLANE_ANGLE_UNIT() SI_UNIT($,.RADIAN.));
#12=(NAMED_UNIT(*) SI_UNIT($,.STERADIAN.) SOLID_ANGLE_UNIT());
#13=UNCERTAINTY_MEASURE_WITH_UNIT(LENGTH_MEASURE(1.E-05),#10,'distance_accuracy_value','');
#14=(GEOMETRIC_REPRESENTATION_CONTEXT(3) GLOBAL_UNCERTAINTY_ASSIGNED_CONTEXT((#13)) GLOBAL_UNIT_ASSIGNED_CONTEXT((#10,
#11,#12)) REPRESENTATION_CONTEXT('',''));
#15=CARTESIAN_POINT('',(0.,0.,0.));
#16=DIRECTION('',(0.,0.,1.));
#17=DIRECTION('',(1.,0.,0.));
#18=AXIS2_PLACEMENT_3D('',#15,#16,#17);
#19=CARTESIAN_POINT('',(0.,0.,152.4));
#20=DIRECTION('',(0.,0.,-1.));
#21=DIRECTION('',(-1.,0.,0.));
#22=AXIS2_PLACEMENT_3D('',#19,#20,#21);
#23=PLANE('',#22);
#24=DIRECTION('',(1.,0.,0.));
#25=VECTOR('',#24,1.);
#26=CARTESIAN_POINT('',(12.7,82.7,152.4));
#27=LINE('',#26,#25);
#28=CARTESIAN_POINT('',(12.7,82.7,152.4));
#29=VERTEX_POINT('',#28);
#30=CARTESIAN_POINT('',(38.1,82.7,152.4));
#31=VERTEX_POINT('',#30);
#32=EDGE_CURVE('E437',#29,#31,#27,.T.);
#33=ORIENTED_EDGE('',*,*,#32,.F.);
#34=DIRECTION('',(0.,-1.,0.));
#35=VECTOR('',#34,1.);
#36=CARTESIAN_POINT('',(12.7,82.7,152.4));
#37=LINE('',#36,#35);
#38=CARTESIAN_POINT('',(12.7,139.7,152.4));
#39=VERTEX_POINT('',#38);
#40=EDGE_CURVE('E47',#39,#29,#37,.T.);
#41=ORIENTED_EDGE('',*,*,#40,.F.);
#42=DIRECTION('',(-1.,0.,0.));
#43=VECTOR('',#42,1.);
#44=CARTESIAN_POINT('',(12.7,139.7,152.4));
#45=LINE('',#44,#43);
#46=CARTESIAN_POINT('',(38.1,139.7,152.4));
#47=VERTEX_POINT('',#46);
#48=EDGE_CURVE('E444',#47,#39,#45,.T.);
#49=ORIENTED_EDGE('',*,*,#48,.F.);
#50=DIRECTION('',(0.,1.,0.));
#51=VECTOR('',#50,1.);
#52=CARTESIAN_POINT('',(38.1,82.7,152.4));
#53=LINE('',#52,#51);
#54=EDGE_CURVE('E428',#31,#47,#53,.T.);
#55=ORIENTED_EDGE('',*,*,#54,.F.);
#56=EDGE_LOOP('',(#33,#41,#49,#55));
#57=FACE_BOUND('',#56,.T.);
#58=DIRECTION('',(1.,0.,0.));
#59=VECTOR('',#58,1.);
#60=CARTESIAN_POINT('',(12.7,12.7,152.4));
#61=LINE('',#60,#59);
#62=CARTESIAN_POINT('',(12.7,12.7,152.4));
#63=VERTEX_POINT('',#62);
#64=CARTESIAN_POINT('',(38.1,12.7,152.4));
#65=VERTEX_POINT('',#64);
#66=EDGE_CURVE('E457',#63,#65,#61,.T.);
#67=ORIENTED_EDGE('',*,*,#66,.F.);
#68=DIRECTION('',(0.,-1.,0.));
#69=VECTOR('',#68,1.);
#70=CARTESIAN_POINT('',(12.7,30.3,152.4));
#71=LINE('',#70,#69);
#72=CARTESIAN_POINT('',(12.7,30.3,152.4));
#73=VERTEX_POINT('',#72);
#74=EDGE_CURVE('E55',#73,#63,#71,.T.);
#75=ORIENTED_EDGE('',*,*,#74,.F.);
#76=DIRECTION('',(-1.,0.,0.));
#77=VECTOR('',#76,1.);
#78=CARTESIAN_POINT('',(12.7,30.3,152.4));
#79=LINE('',#78,#77);
#80=CARTESIAN_POINT('',(38.1,30.3,152.4));
#81=VERTEX_POINT('',#80);
#82=EDGE_CURVE('E464',#81,#73,#79,.T.);
#83=ORIENTED_EDGE('',*,*,#82,.F.);
#84=DIRECTION('',(0.,1.,0.));
#85=VECTOR('',#84,1.);
#86=CARTESIAN_POINT('',(38.1,30.3,152.4));
#87=LINE('',#86,#85);
#88=EDGE_CURVE('E461',#65,#81,#87,.T.);
#89=ORIENTED_EDGE('',*,*,#88,.F.);
#90=EDGE_LOOP('',(#67,#75,#83,#89));
#91=FACE_BOUND('',#90,.T.);
#92=DIRECTION('',(1.,0.,0.));
#93=VECTOR('',#92,1.);
#94=CARTESIAN_POINT('',(30.275,43.,152.4));
#95=LINE('',#94,#93);
#96=CARTESIAN_POINT('',(30.275,43.,152.4));
#97=VERTEX_POINT('',#96);
#98=CARTESIAN_POINT('',(45.925,43.,152.4));
#99=VERTEX_POINT('',#98);
#100=EDGE_CURVE('E481',#97,#99,#95,.T.);
#101=ORIENTED_EDGE('',*,*,#100,.F.);
#102=DIRECTION('',(0.,-1.,0.));
#103=VECTOR('',#102,1.);
#104=CARTESIAN_POINT('',(30.275,70.,152.4));
#105=LINE('',#104,#103);
#106=CARTESIAN_POINT('',(30.275,70.,152.4));
#107=VERTEX_POINT('',#106);
#108=EDGE_CURVE('E479',#107,#97,#105,.T.);
#109=ORIENTED_EDGE('',*,*,#108,.F.);
#110=DIRECTION('',(-1.,0.,0.));
#111=VECTOR('',#110,1.);
#112=CARTESIAN_POINT('',(30.275,70.,152.4));
#113=LINE('',#112,#111);
#114=CARTESIAN_POINT('',(45.925,70.,152.4));
#115=VERTEX_POINT('',#114);
#116=EDGE_CURVE('E487',#115,#107,#113,.T.);
#117=ORIENTED_EDGE('',*,*,#116,.F.);
#118=DIRECTION('',(0.,1.,0.));
#119=VECTOR('',#118,1.);
#120=CARTESIAN_POINT('',(45.925,70.,152.4));
#121=LINE('',#120,#119);
#122=EDGE_CURVE('E484',#99,#115,#121,.T.);
#123=ORIENTED_EDGE('',*,*,#122,.F.);
#124=EDGE_LOOP('',(#101,#109,#117,#123));
#125=FACE_BOUND('',#124,.T.);
#126=CARTESIAN_POINT('',(57.15,25.4,152.4));
#127=DIRECTION('',(0.,0.,1.));
#128=DIRECTION('',(1.,0.,0.));
#129=AXIS2_PLACEMENT_3D('',#126,#127,#128);
#130=CIRCLE('',#129,6.35);
#131=CARTESIAN_POINT('',(63.5,25.4,152.4));
#132=VERTEX_POINT('',#131);
#133=EDGE_CURVE('E572',#132,#132,#130,.T.);
#134=ORIENTED_EDGE('',*,*,#133,.F.);
#135=EDGE_LOOP('',(#134));
#136=FACE_BOUND('',#135,.T.);
#137=DIRECTION('',(0.,-1.,0.));
#138=VECTOR('',#137,1.);
#139=CARTESIAN_POINT('',(50.8,127.,152.4));
#140=LINE('',#139,#138);
#141=CARTESIAN_POINT('',(50.8,127.,152.4));
#142=VERTEX_POINT('',#141);
#143=CARTESIAN_POINT('',(50.8,82.55,152.4));
#144=VERTEX_POINT('',#143);
#145=EDGE_CURVE('E578',#142,#144,#140,.T.);
#146=ORIENTED_EDGE('',*,*,#145,.F.);
#147=CARTESIAN_POINT('',(57.15,127.,152.4));
#148=DIRECTION('',(0.,0.,1.));
#149=DIRECTION('',(1.,0.,0.));
#150=AXIS2_PLACEMENT_3D('',#147,#148,#149);
#151=CIRCLE('',#150,6.34999999999999);
#152=CARTESIAN_POINT('',(63.5,127.,152.4));
#153=VERTEX_POINT('',#152);
#154=EDGE_CURVE('E571',#153,#142,#151,.T.);
#155=ORIENTED_EDGE('',*,*,#154,.F.);
#156=DIRECTION('',(0.,1.,0.));
#157=VECTOR('',#156,1.);
#158=CARTESIAN_POINT('',(63.5,127.,152.4));
#159=LINE('',#158,#157);
#160=CARTESIAN_POINT('',(63.5,82.55,152.4));
#161=VERTEX_POINT('',#160);
#162=EDGE_CURVE('E584',#161,#153,#159,.T.);
#163=ORIENTED_EDGE('',*,*,#162,.F.);
#164=CARTESIAN_POINT('',(57.15,82.55,152.4));
#165=DIRECTION('',(0.,0.,1.));
#166=DIRECTION('',(1.,0.,0.));
#167=AXIS2_PLACEMENT_3D('',#164,#165,#166);
#168=CIRCLE('',#167,6.34999999999999);
#169=EDGE_CURVE('E581',#144,#161,#168,.T.);
#170=ORIENTED_EDGE('',*,*,#169,.F.);
#171=EDGE_LOOP('',(#146,#155,#163,#170));
#172=FACE_BOUND('',#171,.T.);
#173=DIRECTION('',(0.,-1.,0.));
#174=VECTOR('',#173,1.);
#175=CARTESIAN_POINT('',(10.575,70.,152.4));
#176=LINE('',#175,#174);
#177=CARTESIAN_POINT('',(10.575,70.,152.4));
#178=VERTEX_POINT('',#177);
#179=CARTESIAN_POINT('',(10.575,43.,152.4));
#180=VERTEX_POINT('',#179);
#181=EDGE_CURVE('E723',#178,#180,#176,.T.);
#182=ORIENTED_EDGE('',*,*,#181,.F.);
#183=DIRECTION('',(-1.,0.,0.));
#184=VECTOR('',#183,1.);
#185=CARTESIAN_POINT('',(10.575,70.,152.4));
#186=LINE('',#185,#184);
#187=CARTESIAN_POINT('',(17.575,70.,152.4));
#188=VERTEX_POINT('',#187);
#189=EDGE_CURVE('E728',#188,#178,#186,.T.);
#190=ORIENTED_EDGE('',*,*,#189,.F.);
#191=DIRECTION('',(0.,1.,0.));
#192=VECTOR('',#191,1.);
#193=CARTESIAN_POINT('',(17.575,70.,152.4));
#194=LINE('',#193,#192);
#195=CARTESIAN_POINT('',(17.575,43.,152.4));
#196=VERTEX_POINT('',#195);
#197=EDGE_CURVE('E740',#196,#188,#194,.T.);
#198=ORIENTED_EDGE('',*,*,#197,.F.);
#199=DIRECTION('',(1.,0.,0.));
#200=VECTOR('',#199,1.);
#201=CARTESIAN_POINT('',(10.575,43.,152.4));
#202=LINE('',#201,#200);
#203=EDGE_CURVE('E737',#180,#196,#202,.T.);
#204=ORIENTED_EDGE('',*,*,#203,.F.);
#205=EDGE_LOOP('',(#182,#190,#198,#204));
#206=FACE_BOUND('',#205,.T.);
#207=DIRECTION('',(0.,-1.,0.));
#208=VECTOR('',#207,1.);
#209=CARTESIAN_POINT('',(0.,0.,152.4));
#210=LINE('',#209,#208);
#211=CARTESIAN_POINT('',(0.,152.4,152.4));
#212=VERTEX_POINT('',#211);
#213=CARTESIAN_POINT('',(0.,0.,152.4));
#214=VERTEX_POINT('',#213);
#215=EDGE_CURVE('E848',#212,#214,#210,.T.);
#216=ORIENTED_EDGE('',*,*,#215,.T.);
#217=DIRECTION('',(1.,0.,0.));
#218=VECTOR('',#217,1.);
#219=CARTESIAN_POINT('',(0.,0.,152.4));
#220=LINE('',#219,#218);
#221=CARTESIAN_POINT('',(76.2,0.,152.4));
#222=VERTEX_POINT('',#221);
#223=EDGE_CURVE('E851',#214,#222,#220,.T.);
#224=ORIENTED_EDGE('',*,*,#223,.T.);
#225=DIRECTION('',(0.,1.,0.));
#226=VECTOR('',#225,1.);
#227=CARTESIAN_POINT('',(76.2,0.,152.4));
#228=LINE('',#227,#226);
#229=CARTESIAN_POINT('',(76.2,152.4,152.4));
#230=VERTEX_POINT('',#229);
#231=EDGE_CURVE('E854',#222,#230,#228,.T.);
#232=ORIENTED_EDGE('',*,*,#231,.T.);
#233=DIRECTION('',(-1.,0.,0.));
#234=VECTOR('',#233,1.);
#235=CARTESIAN_POINT('',(0.,152.4,152.4));
#236=LINE('',#235,#234);
#237=EDGE_CURVE('E856',#230,#212,#236,.T.);
#238=ORIENTED_EDGE('',*,*,#237,.T.);
#239=EDGE_LOOP('',(#216,#224,#232,#238));
#240=FACE_BOUND('',#239,.T.);
#241=DIRECTION('',(0.,-1.,0.));
#242=VECTOR('',#241,1.);
#243=CARTESIAN_POINT('',(58.625,70.,152.4));
#244=LINE('',#243,#242);
#245=CARTESIAN_POINT('',(58.625,70.,152.4));
#246=VERTEX_POINT('',#245);
#247=CARTESIAN_POINT('',(58.625,43.,152.4));
#248=VERTEX_POINT('',#247);
#249=EDGE_CURVE('E690',#246,#248,#244,.T.);
#250=ORIENTED_EDGE('',*,*,#249,.F.);
#251=DIRECTION('',(-1.,0.,0.));
#252=VECTOR('',#251,1.);
#253=CARTESIAN_POINT('',(58.625,70.,152.4));
#254=LINE('',#253,#252);
#255=CARTESIAN_POINT('',(65.625,70.,152.4));
#256=VERTEX_POINT('',#255);
#257=EDGE_CURVE('E695',#256,#246,#254,.T.);
#258=ORIENTED_EDGE('',*,*,#257,.F.);
#259=DIRECTION('',(0.,1.,0.));
#260=VECTOR('',#259,1.);
#261=CARTESIAN_POINT('',(65.625,70.,152.4));
#262=LINE('',#261,#260);
#263=CARTESIAN_POINT('',(65.625,43.,152.4));
#264=VERTEX_POINT('',#263);
#265=EDGE_CURVE('E707',#264,#256,#262,.T.);
#266=ORIENTED_EDGE('',*,*,#265,.F.);
#267=DIRECTION('',(1.,0.,0.));
#268=VECTOR('',#267,1.);
#269=CARTESIAN_POINT('',(58.625,43.,152.4));
#270=LINE('',#269,#268);
#271=EDGE_CURVE('E704',#248,#264,#270,.T.);
#272=ORIENTED_EDGE('',*,*,#271,.F.);
#273=EDGE_LOOP('',(#250,#258,#266,#272));
#274=FACE_BOUND('',#273,.T.);
#275=ADVANCED_FACE('F32',(#57,#91,#125,#136,#172,#206,#240,#274),#23,.F.);
#276=CARTESIAN_POINT('',(12.7,0.,12.7));
#277=DIRECTION('',(-1.,0.,0.));
#278=DIRECTION('',(0.,0.,1.));
#279=AXIS2_PLACEMENT_3D('',#276,#277,#278);
#280=PLANE('',#279);
#281=DIRECTION('',(0.,1.,0.));
#282=VECTOR('',#281,1.);
#283=CARTESIAN_POINT('',(12.7,0.,12.7));
#284=LINE('',#283,#282);
#285=CARTESIAN_POINT('',(12.7,0.,12.7));
#286=VERTEX_POINT('',#285);
#287=CARTESIAN_POINT('',(12.7,12.7,12.7));
#288=VERTEX_POINT('',#287);
#289=EDGE_CURVE('E832',#286,#288,#284,.T.);
#290=ORIENTED_EDGE('',*,*,#289,.T.);
#291=DIRECTION('',(0.,0.,1.));
#292=VECTOR('',#291,1.);
#293=CARTESIAN_POINT('',(12.7,12.7,12.7));
#294=LINE('',#293,#292);
#295=CARTESIAN_POINT('',(12.7,12.7,139.7));
#296=VERTEX_POINT('',#295);
#297=EDGE_CURVE('E804',#288,#296,#294,.T.);
#298=ORIENTED_EDGE('',*,*,#297,.T.);
#299=DIRECTION('',(0.,1.,0.));
#300=VECTOR('',#299,1.);
#301=CARTESIAN_POINT('',(12.7,0.,139.7));
#302=LINE('',#301,#300);
#303=CARTESIAN_POINT('',(12.7,0.,139.7));
#304=VERTEX_POINT('',#303);
#305=EDGE_CURVE('E845',#304,#296,#302,.T.);
#306=ORIENTED_EDGE('',*,*,#305,.F.);
#307=DIRECTION('',(0.,0.,1.));
#308=VECTOR('',#307,1.);
#309=CARTESIAN_POINT('',(12.7,0.,12.7));
#310=LINE('',#309,#308);
#311=EDGE_CURVE('E808',#286,#304,#310,.T.);
#312=ORIENTED_EDGE('',*,*,#311,.F.);
#313=EDGE_LOOP('',(#290,#298,#306,#312));
#314=FACE_BOUND('',#313,.T.);
#315=ADVANCED_FACE('F940',(#314),#280,.F.);
#316=CARTESIAN_POINT('',(63.5,0.,12.7));
#317=DIRECTION('',(1.,0.,0.));
#318=DIRECTION('',(0.,0.,-1.));
#319=AXIS2_PLACEMENT_3D('',#316,#317,#318);
#320=PLANE('',#319);
#321=DIRECTION('',(0.,1.,0.));
#322=VECTOR('',#321,1.);
#323=CARTESIAN_POINT('',(63.5,0.,139.7));
#324=LINE('',#323,#322);
#325=CARTESIAN_POINT('',(63.5,0.,139.7));
#326=VERTEX_POINT('',#325);
#327=CARTESIAN_POINT('',(63.5,12.7,139.7));
#328=VERTEX_POINT('',#327);
#329=EDGE_CURVE('E841',#326,#328,#324,.T.);
#330=ORIENTED_EDGE('',*,*,#329,.T.);
#331=DIRECTION('',(0.,0.,-1.));
#332=VECTOR('',#331,1.);
#333=CARTESIAN_POINT('',(63.5,12.7,12.7));
#334=LINE('',#333,#332);
#335=CARTESIAN_POINT('',(63.5,12.7,12.7));
#336=VERTEX_POINT('',#335);
#337=EDGE_CURVE('E801',#328,#336,#334,.T.);
#338=ORIENTED_EDGE('',*,*,#337,.T.);
#339=DIRECTION('',(0.,1.,0.));
#340=VECTOR('',#339,1.);
#341=CARTESIAN_POINT('',(63.5,0.,12.7));
#342=LINE('',#341,#340);
#343=CARTESIAN_POINT('',(63.5,0.,12.7));
#344=VERTEX_POINT('',#343);
#345=EDGE_CURVE('E837',#344,#336,#342,.T.);
#346=ORIENTED_EDGE('',*,*,#345,.F.);
#347=DIRECTION('',(0.,0.,-1.));
#348=VECTOR('',#347,1.);
#349=CARTESIAN_POINT('',(63.5,0.,12.7));
#350=LINE('',#349,#348);
#351=EDGE_CURVE('E815',#326,#344,#350,.T.);
#352=ORIENTED_EDGE('',*,*,#351,.F.);
#353=EDGE_LOOP('',(#330,#338,#346,#352));
#354=FACE_BOUND('',#353,.T.);
#355=ADVANCED_FACE('F978',(#354),#320,.F.);
#356=CARTESIAN_POINT('',(0.,0.,152.4));
#357=DIRECTION('',(1.,0.,0.));
#358=DIRECTION('',(0.,0.,-1.));
#359=AXIS2_PLACEMENT_3D('',#356,#357,#358);
#360=PLANE('',#359);
#361=DIRECTION('',(0.,-1.,0.));
#362=VECTOR('',#361,1.);
#363=CARTESIAN_POINT('',(0.,12.7,139.7));
#364=LINE('',#363,#362);
#365=CARTESIAN_POINT('',(0.,139.7,139.7));
#366=VERTEX_POINT('',#365);
#367=CARTESIAN_POINT('',(0.,12.7,139.7));
#368=VERTEX_POINT('',#367);
#369=EDGE_CURVE('E767',#366,#368,#364,.T.);
#370=ORIENTED_EDGE('',*,*,#369,.T.);
#371=DIRECTION('',(0.,0.,-1.));
#372=VECTOR('',#371,1.);
#373=CARTESIAN_POINT('',(0.,12.7,139.7));
#374=LINE('',#373,#372);
#375=CARTESIAN_POINT('',(0.,12.7,12.7));
#376=VERTEX_POINT('',#375);
#377=EDGE_CURVE('E757',#368,#376,#374,.T.);
#378=ORIENTED_EDGE('',*,*,#377,.T.);
#379=DIRECTION('',(0.,1.,0.));
#380=VECTOR('',#379,1.);
#381=CARTESIAN_POINT('',(0.,12.7,12.7));
#382=LINE('',#381,#380);
#383=CARTESIAN_POINT('',(0.,139.7,12.7));
#384=VERTEX_POINT('',#383);
#385=EDGE_CURVE('E760',#376,#384,#382,.T.);
#386=ORIENTED_EDGE('',*,*,#385,.T.);
#387=DIRECTION('',(0.,0.,1.));
#388=VECTOR('',#387,1.);
#389=CARTESIAN_POINT('',(0.,139.7,139.7));
#390=LINE('',#389,#388);
#391=EDGE_CURVE('E764',#384,#366,#390,.T.);
#392=ORIENTED_EDGE('',*,*,#391,.T.);
#393=EDGE_LOOP('',(#370,#378,#386,#392));
#394=FACE_BOUND('',#393,.T.);
#395=DIRECTION('',(0.,-1.,0.));
#396=VECTOR('',#395,1.);
#397=CARTESIAN_POINT('',(0.,0.,0.));
#398=LINE('',#397,#396);
#399=CARTESIAN_POINT('',(0.,152.4,0.));
#400=VERTEX_POINT('',#399);
#401=CARTESIAN_POINT('',(0.,0.,0.));
#402=VERTEX_POINT('',#401);
#403=EDGE_CURVE('E835',#400,#402,#398,.T.);
#404=ORIENTED_EDGE('',*,*,#403,.T.);
#405=DIRECTION('',(0.,0.,-1.));
#406=VECTOR('',#405,1.);
#407=CARTESIAN_POINT('',(0.,0.,152.4));
#408=LINE('',#407,#406);
#409=EDGE_CURVE('E874',#214,#402,#408,.T.);
#410=ORIENTED_EDGE('',*,*,#409,.F.);
#411=ORIENTED_EDGE('',*,*,#215,.F.);
#412=DIRECTION('',(0.,0.,-1.));
#413=VECTOR('',#412,1.);
#414=CARTESIAN_POINT('',(0.,152.4,152.4));
#415=LINE('',#414,#413);
#416=EDGE_CURVE('E858',#212,#400,#415,.T.);
#417=ORIENTED_EDGE('',*,*,#416,.T.);
#418=EDGE_LOOP('',(#404,#410,#411,#417));
#419=FACE_BOUND('',#418,.T.);
#420=ADVANCED_FACE('F34',(#394,#419),#360,.F.);
#421=CARTESIAN_POINT('',(0.,0.,152.4));
#422=DIRECTION('',(0.,1.,0.));
#423=DIRECTION('',(0.,0.,1.));
#424=AXIS2_PLACEMENT_3D('',#421,#422,#423);
#425=PLANE('',#424);
#426=DIRECTION('',(-1.,0.,0.));
#427=VECTOR('',#426,1.);
#428=CARTESIAN_POINT('',(12.7,0.,12.7));
#429=LINE('',#428,#427);
#430=EDGE_CURVE('E818',#344,#286,#429,.T.);
#431=ORIENTED_EDGE('',*,*,#430,.T.);
#432=ORIENTED_EDGE('',*,*,#311,.T.);
#433=DIRECTION('',(1.,0.,0.));
#434=VECTOR('',#433,1.);
#435=CARTESIAN_POINT('',(12.7,0.,139.7));
#436=LINE('',#435,#434);
#437=EDGE_CURVE('E811',#304,#326,#436,.T.);
#438=ORIENTED_EDGE('',*,*,#437,.T.);
#439=ORIENTED_EDGE('',*,*,#351,.T.);
#440=EDGE_LOOP('',(#431,#432,#438,#439));
#441=FACE_BOUND('',#440,.T.);
#442=DIRECTION('',(1.,0.,0.));
#443=VECTOR('',#442,1.);
#444=CARTESIAN_POINT('',(0.,0.,0.));
#445=LINE('',#444,#443);
#446=CARTESIAN_POINT('',(76.2,0.,0.));
#447=VERTEX_POINT('',#446);
#448=EDGE_CURVE('E861',#402,#447,#445,.T.);
#449=ORIENTED_EDGE('',*,*,#448,.T.);
#450=DIRECTION('',(0.,0.,-1.));
#451=VECTOR('',#450,1.);
#452=CARTESIAN_POINT('',(76.2,0.,152.4));
#453=LINE('',#452,#451);
#454=EDGE_CURVE('E871',#222,#447,#453,.T.);
#455=ORIENTED_EDGE('',*,*,#454,.F.);
#456=ORIENTED_EDGE('',*,*,#223,.F.);
#457=ORIENTED_EDGE('',*,*,#409,.T.);
#458=EDGE_LOOP('',(#449,#455,#456,#457));
#459=FACE_BOUND('',#458,.T.);
#460=ADVANCED_FACE('F992',(#441,#459),#425,.F.);
#461=CARTESIAN_POINT('',(76.2,0.,152.4));
#462=DIRECTION('',(-1.,0.,0.));
#463=DIRECTION('',(0.,0.,1.));
#464=AXIS2_PLACEMENT_3D('',#461,#462,#463);
#465=PLANE('',#464);
#466=DIRECTION('',(0.,1.,0.));
#467=VECTOR('',#466,1.);
#468=CARTESIAN_POINT('',(76.2,12.7,12.7));
#469=LINE('',#468,#467);
#470=CARTESIAN_POINT('',(76.2,12.7,12.7));
#471=VERTEX_POINT('',#470);
#472=CARTESIAN_POINT('',(76.2,139.7,12.7));
#473=VERTEX_POINT('',#472);
#474=EDGE_CURVE('E772',#471,#473,#469,.T.);
#475=ORIENTED_EDGE('',*,*,#474,.F.);
#476=DIRECTION('',(0.,0.,-1.));
#477=VECTOR('',#476,1.);
#478=CARTESIAN_POINT('',(76.2,12.7,139.7));
#479=LINE('',#478,#477);
#480=CARTESIAN_POINT('',(76.2,12.7,139.7));
#481=VERTEX_POINT('',#480);
#482=EDGE_CURVE('E756',#481,#471,#479,.T.);
#483=ORIENTED_EDGE('',*,*,#482,.F.);
#484=DIRECTION('',(0.,-1.,0.));
#485=VECTOR('',#484,1.);
#486=CARTESIAN_POINT('',(76.2,12.7,139.7));
#487=LINE('',#486,#485);
#488=CARTESIAN_POINT('',(76.2,139.7,139.7));
#489=VERTEX_POINT('',#488);
#490=EDGE_CURVE('E761',#489,#481,#487,.T.);
#491=ORIENTED_EDGE('',*,*,#490,.F.);
#492=DIRECTION('',(0.,0.,1.));
#493=VECTOR('',#492,1.);
#494=CARTESIAN_POINT('',(76.2,139.7,139.7));
#495=LINE('',#494,#493);
#496=EDGE_CURVE('E775',#473,#489,#495,.T.);
#497=ORIENTED_EDGE('',*,*,#496,.F.);
#498=EDGE_LOOP('',(#475,#483,#491,#497));
#499=FACE_BOUND('',#498,.T.);
#500=DIRECTION('',(0.,1.,0.));
#501=VECTOR('',#500,1.);
#502=CARTESIAN_POINT('',(76.2,0.,0.));
#503=LINE('',#502,#501);
#504=CARTESIAN_POINT('',(76.2,152.4,0.));
#505=VERTEX_POINT('',#504);
#506=EDGE_CURVE('E863',#447,#505,#503,.T.);
#507=ORIENTED_EDGE('',*,*,#506,.T.);
#508=DIRECTION('',(0.,0.,-1.));
#509=VECTOR('',#508,1.);
#510=CARTESIAN_POINT('',(76.2,152.4,152.4));
#511=LINE('',#510,#509);
#512=EDGE_CURVE('E868',#230,#505,#511,.T.);
#513=ORIENTED_EDGE('',*,*,#512,.F.);
#514=ORIENTED_EDGE('',*,*,#231,.F.);
#515=ORIENTED_EDGE('',*,*,#454,.T.);
#516=EDGE_LOOP('',(#507,#513,#514,#515));
#517=FACE_BOUND('',#516,.T.);
#518=ADVANCED_FACE('F989',(#499,#517),#465,.F.);
#519=CARTESIAN_POINT('',(0.,152.4,152.4));
#520=DIRECTION('',(0.,-1.,0.));
#521=DIRECTION('',(0.,0.,-1.));
#522=AXIS2_PLACEMENT_3D('',#519,#520,#521);
#523=PLANE('',#522);
#524=DIRECTION('',(1.,0.,0.));
#525=VECTOR('',#524,1.);
#526=CARTESIAN_POINT('',(12.7,152.4,139.7));
#527=LINE('',#526,#525);
#528=CARTESIAN_POINT('',(12.7,152.4,139.7));
#529=VERTEX_POINT('',#528);
#530=CARTESIAN_POINT('',(63.5,152.4,139.7));
#531=VERTEX_POINT('',#530);
#532=EDGE_CURVE('E824',#529,#531,#527,.T.);
#533=ORIENTED_EDGE('',*,*,#532,.F.);
#534=DIRECTION('',(0.,0.,1.));
#535=VECTOR('',#534,1.);
#536=CARTESIAN_POINT('',(12.7,152.4,12.7));
#537=LINE('',#536,#535);
#538=CARTESIAN_POINT('',(12.7,152.4,12.7));
#539=VERTEX_POINT('',#538);
#540=EDGE_CURVE('E807',#539,#529,#537,.T.);
#541=ORIENTED_EDGE('',*,*,#540,.F.);
#542=DIRECTION('',(-1.,0.,0.));
#543=VECTOR('',#542,1.);
#544=CARTESIAN_POINT('',(12.7,152.4,12.7));
#545=LINE('',#544,#543);
#546=CARTESIAN_POINT('',(63.5,152.4,12.7));
#547=VERTEX_POINT('',#546);
#548=EDGE_CURVE('E812',#547,#539,#545,.T.);
#549=ORIENTED_EDGE('',*,*,#548,.F.);
#550=DIRECTION('',(0.,0.,-1.));
#551=VECTOR('',#550,1.);
#552=CARTESIAN_POINT('',(63.5,152.4,12.7));
#553=LINE('',#552,#551);
#554=EDGE_CURVE('E827',#531,#547,#553,.T.);
#555=ORIENTED_EDGE('',*,*,#554,.F.);
#556=EDGE_LOOP('',(#533,#541,#549,#555));
#557=FACE_BOUND('',#556,.T.);
#558=DIRECTION('',(-1.,0.,0.));
#559=VECTOR('',#558,1.);
#560=CARTESIAN_POINT('',(0.,152.4,0.));
#561=LINE('',#560,#559);
#562=EDGE_CURVE('E852',#505,#400,#561,.T.);
#563=ORIENTED_EDGE('',*,*,#562,.T.);
#564=ORIENTED_EDGE('',*,*,#416,.F.);
#565=ORIENTED_EDGE('',*,*,#237,.F.);
#566=ORIENTED_EDGE('',*,*,#512,.T.);
#567=EDGE_LOOP('',(#563,#564,#565,#566));
#568=FACE_BOUND('',#567,.T.);
#569=ADVANCED_FACE('F985',(#557,#568),#523,.F.);
#570=CARTESIAN_POINT('',(0.,0.,0.));
#571=DIRECTION('',(0.,0.,-1.));
#572=DIRECTION('',(-1.,0.,0.));
#573=AXIS2_PLACEMENT_3D('',#570,#571,#572);
#574=PLANE('',#573);
#575=DIRECTION('',(0.,1.,0.));
#576=VECTOR('',#575,1.);
#577=CARTESIAN_POINT('',(12.7,0.,0.));
#578=LINE('',#577,#576);
#579=CARTESIAN_POINT('',(12.7,82.7,0.));
#580=VERTEX_POINT('',#579);
#581=CARTESIAN_POINT('',(12.7,139.7,0.));
#582=VERTEX_POINT('',#581);
#583=EDGE_CURVE('E508',#580,#582,#578,.T.);
#584=ORIENTED_EDGE('',*,*,#583,.F.);
#585=DIRECTION('',(-1.,0.,0.));
#586=VECTOR('',#585,1.);
#587=CARTESIAN_POINT('',(0.,82.7,0.));
#588=LINE('',#587,#586);
#589=CARTESIAN_POINT('',(38.1,82.7,0.));
#590=VERTEX_POINT('',#589);
#591=EDGE_CURVE('E558',#590,#580,#588,.T.);
#592=ORIENTED_EDGE('',*,*,#591,.F.);
#593=DIRECTION('',(0.,-1.,0.));
#594=VECTOR('',#593,1.);
#595=CARTESIAN_POINT('',(38.1,0.,0.));
#596=LINE('',#595,#594);
#597=CARTESIAN_POINT('',(38.1,139.7,0.));
#598=VERTEX_POINT('',#597);
#599=EDGE_CURVE('E563',#598,#590,#596,.T.);
#600=ORIENTED_EDGE('',*,*,#599,.F.);
#601=DIRECTION('',(1.,0.,0.));
#602=VECTOR('',#601,1.);
#603=CARTESIAN_POINT('',(0.,139.7,0.));
#604=LINE('',#603,#602);
#605=EDGE_CURVE('E569',#582,#598,#604,.T.);
#606=ORIENTED_EDGE('',*,*,#605,.F.);
#607=EDGE_LOOP('',(#584,#592,#600,#606));
#608=FACE_BOUND('',#607,.T.);
#609=DIRECTION('',(0.,1.,0.));
#610=VECTOR('',#609,1.);
#611=CARTESIAN_POINT('',(12.7,0.,0.));
#612=LINE('',#611,#610);
#613=CARTESIAN_POINT('',(12.7,12.7,0.));
#614=VERTEX_POINT('',#613);
#615=CARTESIAN_POINT('',(12.7,30.3,0.));
#616=VERTEX_POINT('',#615);
#617=EDGE_CURVE('E516',#614,#616,#612,.T.);
#618=ORIENTED_EDGE('',*,*,#617,.F.);
#619=DIRECTION('',(-1.,0.,0.));
#620=VECTOR('',#619,1.);
#621=CARTESIAN_POINT('',(0.,12.7,0.));
#622=LINE('',#621,#620);
#623=CARTESIAN_POINT('',(38.1,12.7,0.));
#624=VERTEX_POINT('',#623);
#625=EDGE_CURVE('E542',#624,#614,#622,.T.);
#626=ORIENTED_EDGE('',*,*,#625,.F.);
#627=DIRECTION('',(0.,-1.,0.));
#628=VECTOR('',#627,1.);
#629=CARTESIAN_POINT('',(38.1,0.,0.));
#630=LINE('',#629,#628);
#631=CARTESIAN_POINT('',(38.1,30.3,0.));
#632=VERTEX_POINT('',#631);
#633=EDGE_CURVE('E547',#632,#624,#630,.T.);
#634=ORIENTED_EDGE('',*,*,#633,.F.);
#635=DIRECTION('',(1.,0.,0.));
#636=VECTOR('',#635,1.);
#637=CARTESIAN_POINT('',(0.,30.3,0.));
#638=LINE('',#637,#636);
#639=EDGE_CURVE('E553',#616,#632,#638,.T.);
#640=ORIENTED_EDGE('',*,*,#639,.F.);
#641=EDGE_LOOP('',(#618,#626,#634,#640));
#642=FACE_BOUND('',#641,.T.);
#643=DIRECTION('',(0.,1.,0.));
#644=VECTOR('',#643,1.);
#645=CARTESIAN_POINT('',(30.275,0.,0.));
#646=LINE('',#645,#644);
#647=CARTESIAN_POINT('',(30.275,43.,0.));
#648=VERTEX_POINT('',#647);
#649=CARTESIAN_POINT('',(30.275,70.,0.));
#650=VERTEX_POINT('',#649);
#651=EDGE_CURVE('E537',#648,#650,#646,.T.);
#652=ORIENTED_EDGE('',*,*,#651,.F.);
#653=DIRECTION('',(-1.,0.,0.));
#654=VECTOR('',#653,1.);
#655=CARTESIAN_POINT('',(0.,43.,0.));
#656=LINE('',#655,#654);
#657=CARTESIAN_POINT('',(45.925,43.,0.));
#658=VERTEX_POINT('',#657);
#659=EDGE_CURVE('E521',#658,#648,#656,.T.);
#660=ORIENTED_EDGE('',*,*,#659,.F.);
#661=DIRECTION('',(0.,-1.,0.));
#662=VECTOR('',#661,1.);
#663=CARTESIAN_POINT('',(45.925,0.,0.));
#664=LINE('',#663,#662);
#665=CARTESIAN_POINT('',(45.925,70.,0.));
#666=VERTEX_POINT('',#665);
#667=EDGE_CURVE('E526',#666,#658,#664,.T.);
#668=ORIENTED_EDGE('',*,*,#667,.F.);
#669=DIRECTION('',(1.,0.,0.));
#670=VECTOR('',#669,1.);
#671=CARTESIAN_POINT('',(0.,70.,0.));
#672=LINE('',#671,#670);
#673=EDGE_CURVE('E532',#650,#666,#672,.T.);
#674=ORIENTED_EDGE('',*,*,#673,.F.);
#675=EDGE_LOOP('',(#652,#660,#668,#674));
#676=FACE_BOUND('',#675,.T.);
#677=CARTESIAN_POINT('',(57.15,25.4,0.));
#678=DIRECTION('',(0.,0.,-1.));
#679=DIRECTION('',(-1.,0.,0.));
#680=AXIS2_PLACEMENT_3D('',#677,#678,#679);
#681=CIRCLE('',#680,6.35);
#682=CARTESIAN_POINT('',(50.8,25.4,0.));
#683=VERTEX_POINT('',#682);
#684=EDGE_CURVE('E623',#683,#683,#681,.T.);
#685=ORIENTED_EDGE('',*,*,#684,.F.);
#686=EDGE_LOOP('',(#685));
#687=FACE_BOUND('',#686,.T.);
#688=CARTESIAN_POINT('',(57.15,127.,0.));
#689=DIRECTION('',(0.,0.,-1.));
#690=DIRECTION('',(-1.,0.,0.));
#691=AXIS2_PLACEMENT_3D('',#688,#689,#690);
#692=CIRCLE('',#691,6.34999999999999);
#693=CARTESIAN_POINT('',(50.8,127.,0.));
#694=VERTEX_POINT('',#693);
#695=CARTESIAN_POINT('',(63.5,127.,0.));
#696=VERTEX_POINT('',#695);
#697=EDGE_CURVE('E617',#694,#696,#692,.T.);
#698=ORIENTED_EDGE('',*,*,#697,.F.);
#699=DIRECTION('',(0.,1.,0.));
#700=VECTOR('',#699,1.);
#701=CARTESIAN_POINT('',(50.8,0.,0.));
#702=LINE('',#701,#700);
#703=CARTESIAN_POINT('',(50.8,82.55,0.));
#704=VERTEX_POINT('',#703);
#705=EDGE_CURVE('E601',#704,#694,#702,.T.);
#706=ORIENTED_EDGE('',*,*,#705,.F.);
#707=CARTESIAN_POINT('',(57.15,82.55,0.));
#708=DIRECTION('',(0.,0.,-1.));
#709=DIRECTION('',(-1.,0.,0.));
#710=AXIS2_PLACEMENT_3D('',#707,#708,#709);
#711=CIRCLE('',#710,6.34999999999999);
#712=CARTESIAN_POINT('',(63.5,82.55,0.));
#713=VERTEX_POINT('',#712);
#714=EDGE_CURVE('E606',#713,#704,#711,.T.);
#715=ORIENTED_EDGE('',*,*,#714,.F.);
#716=DIRECTION('',(0.,-1.,0.));
#717=VECTOR('',#716,1.);
#718=CARTESIAN_POINT('',(63.5,0.,0.));
#719=LINE('',#718,#717);
#720=EDGE_CURVE('E612',#696,#713,#719,.T.);
#721=ORIENTED_EDGE('',*,*,#720,.F.);
#722=EDGE_LOOP('',(#698,#706,#715,#721));
#723=FACE_BOUND('',#722,.T.);
#724=DIRECTION('',(0.,-1.,0.));
#725=VECTOR('',#724,1.);
#726=CARTESIAN_POINT('',(58.625,70.,0.));
#727=LINE('',#726,#725);
#728=CARTESIAN_POINT('',(58.625,70.,0.));
#729=VERTEX_POINT('',#728);
#730=CARTESIAN_POINT('',(58.625,43.,0.));
#731=VERTEX_POINT('',#730);
#732=EDGE_CURVE('E626',#729,#731,#727,.T.);
#733=ORIENTED_EDGE('',*,*,#732,.T.);
#734=DIRECTION('',(1.,0.,0.));
#735=VECTOR('',#734,1.);
#736=CARTESIAN_POINT('',(58.625,43.,0.));
#737=LINE('',#736,#735);
#738=CARTESIAN_POINT('',(65.625,43.,0.));
#739=VERTEX_POINT('',#738);
#740=EDGE_CURVE('E631',#731,#739,#737,.T.);
#741=ORIENTED_EDGE('',*,*,#740,.T.);
#742=DIRECTION('',(0.,1.,0.));
#743=VECTOR('',#742,1.);
#744=CARTESIAN_POINT('',(65.625,70.,0.));
#745=LINE('',#744,#743);
#746=CARTESIAN_POINT('',(65.625,70.,0.));
#747=VERTEX_POINT('',#746);
#748=EDGE_CURVE('E644',#739,#747,#745,.T.);
#749=ORIENTED_EDGE('',*,*,#748,.T.);
#750=DIRECTION('',(-1.,0.,0.));
#751=VECTOR('',#750,1.);
#752=CARTESIAN_POINT('',(58.625,70.,0.));
#753=LINE('',#752,#751);
#754=EDGE_CURVE('E642',#747,#729,#753,.T.);
#755=ORIENTED_EDGE('',*,*,#754,.T.);
#756=EDGE_LOOP('',(#733,#741,#749,#755));
#757=FACE_BOUND('',#756,.T.);
#758=DIRECTION('',(0.,-1.,0.));
#759=VECTOR('',#758,1.);
#760=CARTESIAN_POINT('',(10.575,70.,0.));
#761=LINE('',#760,#759);
#762=CARTESIAN_POINT('',(10.575,70.,0.));
#763=VERTEX_POINT('',#762);
#764=CARTESIAN_POINT('',(10.575,43.,0.));
#765=VERTEX_POINT('',#764);
#766=EDGE_CURVE('E658',#763,#765,#761,.T.);
#767=ORIENTED_EDGE('',*,*,#766,.T.);
#768=DIRECTION('',(1.,0.,0.));
#769=VECTOR('',#768,1.);
#770=CARTESIAN_POINT('',(10.575,43.,0.));
#771=LINE('',#770,#769);
#772=CARTESIAN_POINT('',(17.575,43.,0.));
#773=VERTEX_POINT('',#772);
#774=EDGE_CURVE('E663',#765,#773,#771,.T.);
#775=ORIENTED_EDGE('',*,*,#774,.T.);
#776=DIRECTION('',(0.,1.,0.));
#777=VECTOR('',#776,1.);
#778=CARTESIAN_POINT('',(17.575,70.,0.));
#779=LINE('',#778,#777);
#780=CARTESIAN_POINT('',(17.575,70.,0.));
#781=VERTEX_POINT('',#780);
#782=EDGE_CURVE('E676',#773,#781,#779,.T.);
#783=ORIENTED_EDGE('',*,*,#782,.T.);
#784=DIRECTION('',(-1.,0.,0.));
#785=VECTOR('',#784,1.);
#786=CARTESIAN_POINT('',(10.575,70.,0.));
#787=LINE('',#786,#785);
#788=EDGE_CURVE('E674',#781,#763,#787,.T.);
#789=ORIENTED_EDGE('',*,*,#788,.T.);
#790=EDGE_LOOP('',(#767,#775,#783,#789));
#791=FACE_BOUND('',#790,.T.);
#792=ORIENTED_EDGE('',*,*,#403,.F.);
#793=ORIENTED_EDGE('',*,*,#562,.F.);
#794=ORIENTED_EDGE('',*,*,#506,.F.);
#795=ORIENTED_EDGE('',*,*,#448,.F.);
#796=EDGE_LOOP('',(#792,#793,#794,#795));
#797=FACE_BOUND('',#796,.T.);
#798=ADVANCED_FACE('F952',(#608,#642,#676,#687,#723,#757,#791,#797),#574,.T.);
#799=CARTESIAN_POINT('',(12.7,139.7,139.7));
#800=VERTEX_POINT('',#799);
#801=EDGE_CURVE('E821',#800,#529,#302,.T.);
#802=ORIENTED_EDGE('',*,*,#801,.F.);
#803=DIRECTION('',(0.,0.,-1.));
#804=VECTOR('',#803,1.);
#805=CARTESIAN_POINT('',(12.7,139.7,12.7));
#806=LINE('',#805,#804);
#807=CARTESIAN_POINT('',(12.7,139.7,12.7));
#808=VERTEX_POINT('',#807);
#809=EDGE_CURVE('E798',#800,#808,#806,.T.);
#810=ORIENTED_EDGE('',*,*,#809,.T.);
#811=EDGE_CURVE('E836',#808,#539,#284,.T.);
#812=ORIENTED_EDGE('',*,*,#811,.T.);
#813=ORIENTED_EDGE('',*,*,#540,.T.);
#814=EDGE_LOOP('',(#802,#810,#812,#813));
#815=FACE_BOUND('',#814,.T.);
#816=ADVANCED_FACE('F980',(#815),#280,.F.);
#817=CARTESIAN_POINT('',(12.7,0.,12.7));
#818=DIRECTION('',(0.,0.,-1.));
#819=DIRECTION('',(-1.,0.,0.));
#820=AXIS2_PLACEMENT_3D('',#817,#818,#819);
#821=PLANE('',#820);
#822=DIRECTION('',(-1.,0.,0.));
#823=VECTOR('',#822,1.);
#824=CARTESIAN_POINT('',(12.7,43.,12.7));
#825=LINE('',#824,#823);
#826=CARTESIAN_POINT('',(45.925,43.,12.7));
#827=VERTEX_POINT('',#826);
#828=CARTESIAN_POINT('',(30.275,43.,12.7));
#829=VERTEX_POINT('',#828);
#830=EDGE_CURVE('E518',#827,#829,#825,.T.);
#831=ORIENTED_EDGE('',*,*,#830,.T.);
#832=DIRECTION('',(0.,1.,0.));
#833=VECTOR('',#832,1.);
#834=CARTESIAN_POINT('',(30.275,0.,12.7));
#835=LINE('',#834,#833);
#836=CARTESIAN_POINT('',(30.275,70.,12.7));
#837=VERTEX_POINT('',#836);
#838=EDGE_CURVE('E534',#829,#837,#835,.T.);
#839=ORIENTED_EDGE('',*,*,#838,.T.);
#840=DIRECTION('',(1.,0.,0.));
#841=VECTOR('',#840,1.);
#842=CARTESIAN_POINT('',(12.7,70.,12.7));
#843=LINE('',#842,#841);
#844=CARTESIAN_POINT('',(45.925,70.,12.7));
#845=VERTEX_POINT('',#844);
#846=EDGE_CURVE('E529',#837,#845,#843,.T.);
#847=ORIENTED_EDGE('',*,*,#846,.T.);
#848=DIRECTION('',(0.,-1.,0.));
#849=VECTOR('',#848,1.);
#850=CARTESIAN_POINT('',(45.925,0.,12.7));
#851=LINE('',#850,#849);
#852=EDGE_CURVE('E523',#845,#827,#851,.T.);
#853=ORIENTED_EDGE('',*,*,#852,.T.);
#854=EDGE_LOOP('',(#831,#839,#847,#853));
#855=FACE_BOUND('',#854,.T.);
#856=CARTESIAN_POINT('',(57.15,25.4,12.7));
#857=DIRECTION('',(0.,0.,-1.));
#858=DIRECTION('',(-1.,0.,0.));
#859=AXIS2_PLACEMENT_3D('',#856,#857,#858);
#860=CIRCLE('',#859,6.35);
#861=CARTESIAN_POINT('',(50.8,25.4,12.7));
#862=VERTEX_POINT('',#861);
#863=EDGE_CURVE('E620',#862,#862,#860,.T.);
#864=ORIENTED_EDGE('',*,*,#863,.T.);
#865=EDGE_LOOP('',(#864));
#866=FACE_BOUND('',#865,.T.);
#867=DIRECTION('',(0.,1.,0.));
#868=VECTOR('',#867,1.);
#869=CARTESIAN_POINT('',(50.8,0.,12.7));
#870=LINE('',#869,#868);
#871=CARTESIAN_POINT('',(50.8,82.55,12.7));
#872=VERTEX_POINT('',#871);
#873=CARTESIAN_POINT('',(50.8,127.,12.7));
#874=VERTEX_POINT('',#873);
#875=EDGE_CURVE('E575',#872,#874,#870,.T.);
#876=ORIENTED_EDGE('',*,*,#875,.T.);
#877=CARTESIAN_POINT('',(57.15,127.,12.7));
#878=DIRECTION('',(0.,0.,-1.));
#879=DIRECTION('',(-1.,0.,0.));
#880=AXIS2_PLACEMENT_3D('',#877,#878,#879);
#881=CIRCLE('',#880,6.34999999999999);
#882=CARTESIAN_POINT('',(63.5,127.,12.7));
#883=VERTEX_POINT('',#882);
#884=EDGE_CURVE('E614',#874,#883,#881,.T.);
#885=ORIENTED_EDGE('',*,*,#884,.T.);
#886=DIRECTION('',(0.,-1.,0.));
#887=VECTOR('',#886,1.);
#888=CARTESIAN_POINT('',(63.5,0.,12.7));
#889=LINE('',#888,#887);
#890=CARTESIAN_POINT('',(63.5,82.55,12.7));
#891=VERTEX_POINT('',#890);
#892=EDGE_CURVE('E609',#883,#891,#889,.T.);
#893=ORIENTED_EDGE('',*,*,#892,.T.);
#894=CARTESIAN_POINT('',(57.15,82.55,12.7));
#895=DIRECTION('',(0.,0.,-1.));
#896=DIRECTION('',(-1.,0.,0.));
#897=AXIS2_PLACEMENT_3D('',#894,#895,#896);
#898=CIRCLE('',#897,6.34999999999999);
#899=EDGE_CURVE('E603',#891,#872,#898,.T.);
#900=ORIENTED_EDGE('',*,*,#899,.T.);
#901=EDGE_LOOP('',(#876,#885,#893,#900));
#902=FACE_BOUND('',#901,.T.);
#903=DIRECTION('',(-1.,0.,0.));
#904=VECTOR('',#903,1.);
#905=CARTESIAN_POINT('',(12.7,82.7,12.7));
#906=LINE('',#905,#904);
#907=CARTESIAN_POINT('',(38.1,82.7,12.7));
#908=VERTEX_POINT('',#907);
#909=CARTESIAN_POINT('',(12.7,82.7,12.7));
#910=VERTEX_POINT('',#909);
#911=EDGE_CURVE('E555',#908,#910,#906,.T.);
#912=ORIENTED_EDGE('',*,*,#911,.T.);
#913=DIRECTION('',(0.,1.,0.));
#914=VECTOR('',#913,1.);
#915=CARTESIAN_POINT('',(12.7,0.,12.7));
#916=LINE('',#915,#914);
#917=EDGE_CURVE('E505',#910,#808,#916,.T.);
#918=ORIENTED_EDGE('',*,*,#917,.T.);
#919=DIRECTION('',(1.,0.,0.));
#920=VECTOR('',#919,1.);
#921=CARTESIAN_POINT('',(0.,139.7,12.7));
#922=LINE('',#921,#920);
#923=EDGE_CURVE('E789',#384,#808,#922,.T.);
#924=ORIENTED_EDGE('',*,*,#923,.F.);
#925=ORIENTED_EDGE('',*,*,#385,.F.);
#926=DIRECTION('',(1.,0.,0.));
#927=VECTOR('',#926,1.);
#928=CARTESIAN_POINT('',(0.,12.7,12.7));
#929=LINE('',#928,#927);
#930=EDGE_CURVE('E793',#376,#288,#929,.T.);
#931=ORIENTED_EDGE('',*,*,#930,.T.);
#932=DIRECTION('',(0.,1.,0.));
#933=VECTOR('',#932,1.);
#934=CARTESIAN_POINT('',(12.7,0.,12.7));
#935=LINE('',#934,#933);
#936=CARTESIAN_POINT('',(12.7,30.3,12.7));
#937=VERTEX_POINT('',#936);
#938=EDGE_CURVE('E513',#288,#937,#935,.T.);
#939=ORIENTED_EDGE('',*,*,#938,.T.);
#940=DIRECTION('',(1.,0.,0.));
#941=VECTOR('',#940,1.);
#942=CARTESIAN_POINT('',(12.7,30.3,12.7));
#943=LINE('',#942,#941);
#944=CARTESIAN_POINT('',(38.1,30.3,12.7));
#945=VERTEX_POINT('',#944);
#946=EDGE_CURVE('E550',#937,#945,#943,.T.);
#947=ORIENTED_EDGE('',*,*,#946,.T.);
#948=DIRECTION('',(0.,-1.,0.));
#949=VECTOR('',#948,1.);
#950=CARTESIAN_POINT('',(38.1,0.,12.7));
#951=LINE('',#950,#949);
#952=CARTESIAN_POINT('',(38.1,12.7,12.7));
#953=VERTEX_POINT('',#952);
#954=EDGE_CURVE('E544',#945,#953,#951,.T.);
#955=ORIENTED_EDGE('',*,*,#954,.T.);
#956=DIRECTION('',(-1.,0.,0.));
#957=VECTOR('',#956,1.);
#958=CARTESIAN_POINT('',(12.7,12.7,12.7));
#959=LINE('',#958,#957);
#960=EDGE_CURVE('E539',#953,#288,#959,.T.);
#961=ORIENTED_EDGE('',*,*,#960,.T.);
#962=ORIENTED_EDGE('',*,*,#289,.F.);
#963=ORIENTED_EDGE('',*,*,#430,.F.);
#964=ORIENTED_EDGE('',*,*,#345,.T.);
#965=EDGE_CURVE('E770',#336,#471,#929,.T.);
#966=ORIENTED_EDGE('',*,*,#965,.T.);
#967=ORIENTED_EDGE('',*,*,#474,.T.);
#968=CARTESIAN_POINT('',(63.5,139.7,12.7));
#969=VERTEX_POINT('',#968);
#970=EDGE_CURVE('E792',#969,#473,#922,.T.);
#971=ORIENTED_EDGE('',*,*,#970,.F.);
#972=EDGE_CURVE('E840',#969,#547,#342,.T.);
#973=ORIENTED_EDGE('',*,*,#972,.T.);
#974=ORIENTED_EDGE('',*,*,#548,.T.);
#975=ORIENTED_EDGE('',*,*,#811,.F.);
#976=DIRECTION('',(1.,0.,0.));
#977=VECTOR('',#976,1.);
#978=CARTESIAN_POINT('',(12.7,139.7,12.7));
#979=LINE('',#978,#977);
#980=CARTESIAN_POINT('',(38.1,139.7,12.7));
#981=VERTEX_POINT('',#980);
#982=EDGE_CURVE('E566',#808,#981,#979,.T.);
#983=ORIENTED_EDGE('',*,*,#982,.T.);
#984=DIRECTION('',(0.,-1.,0.));
#985=VECTOR('',#984,1.);
#986=CARTESIAN_POINT('',(38.1,0.,12.7));
#987=LINE('',#986,#985);
#988=EDGE_CURVE('E560',#981,#908,#987,.T.);
#989=ORIENTED_EDGE('',*,*,#988,.T.);
#990=EDGE_LOOP('',(#912,#918,#924,#925,#931,#939,#947,#955,#961,#962,#963,#964,#966,#967,#971,
#973,#974,#975,#983,#989));
#991=FACE_BOUND('',#990,.T.);
#992=ADVANCED_FACE('F931',(#855,#866,#902,#991),#821,.F.);
#993=ORIENTED_EDGE('',*,*,#972,.F.);
#994=DIRECTION('',(0.,0.,1.));
#995=VECTOR('',#994,1.);
#996=CARTESIAN_POINT('',(63.5,139.7,12.7));
#997=LINE('',#996,#995);
#998=CARTESIAN_POINT('',(63.5,139.7,139.7));
#999=VERTEX_POINT('',#998);
#1000=EDGE_CURVE('E783',#969,#999,#997,.T.);
#1001=ORIENTED_EDGE('',*,*,#1000,.T.);
#1002=EDGE_CURVE('E844',#999,#531,#324,.T.);
#1003=ORIENTED_EDGE('',*,*,#1002,.T.);
#1004=ORIENTED_EDGE('',*,*,#554,.T.);
#1005=EDGE_LOOP('',(#993,#1001,#1003,#1004));
#1006=FACE_BOUND('',#1005,.T.);
#1007=ADVANCED_FACE('F1074',(#1006),#320,.F.);
#1008=CARTESIAN_POINT('',(12.7,0.,139.7));
#1009=DIRECTION('',(0.,0.,1.));
#1010=DIRECTION('',(1.,0.,0.));
#1011=AXIS2_PLACEMENT_3D('',#1008,#1009,#1010);
#1012=PLANE('',#1011);
#1013=DIRECTION('',(1.,0.,0.));
#1014=VECTOR('',#1013,1.);
#1015=CARTESIAN_POINT('',(0.,139.7,139.7));
#1016=LINE('',#1015,#1014);
#1017=EDGE_CURVE('E785',#366,#800,#1016,.T.);
#1018=ORIENTED_EDGE('',*,*,#1017,.T.);
#1019=DIRECTION('',(0.,-1.,0.));
#1020=VECTOR('',#1019,1.);
#1021=CARTESIAN_POINT('',(12.7,0.,139.7));
#1022=LINE('',#1021,#1020);
#1023=CARTESIAN_POINT('',(12.7,82.7,139.7));
#1024=VERTEX_POINT('',#1023);
#1025=EDGE_CURVE('E502',#800,#1024,#1022,.T.);
#1026=ORIENTED_EDGE('',*,*,#1025,.T.);
#1027=DIRECTION('',(1.,0.,0.));
#1028=VECTOR('',#1027,1.);
#1029=CARTESIAN_POINT('',(12.7,82.7,139.7));
#1030=LINE('',#1029,#1028);
#1031=CARTESIAN_POINT('',(38.1,82.7,139.7));
#1032=VERTEX_POINT('',#1031);
#1033=EDGE_CURVE('E912',#1024,#1032,#1030,.T.);
#1034=ORIENTED_EDGE('',*,*,#1033,.T.);
#1035=DIRECTION('',(0.,1.,0.));
#1036=VECTOR('',#1035,1.);
#1037=CARTESIAN_POINT('',(38.1,0.,139.7));
#1038=LINE('',#1037,#1036);
#1039=CARTESIAN_POINT('',(38.1,139.7,139.7));
#1040=VERTEX_POINT('',#1039);
#1041=EDGE_CURVE('E40',#1032,#1040,#1038,.T.);
#1042=ORIENTED_EDGE('',*,*,#1041,.T.);
#1043=DIRECTION('',(-1.,0.,0.));
#1044=VECTOR('',#1043,1.);
#1045=CARTESIAN_POINT('',(12.7,139.7,139.7));
#1046=LINE('',#1045,#1044);
#1047=EDGE_CURVE('E11',#1040,#800,#1046,.T.);
#1048=ORIENTED_EDGE('',*,*,#1047,.T.);
#1049=ORIENTED_EDGE('',*,*,#801,.T.);
#1050=ORIENTED_EDGE('',*,*,#532,.T.);
#1051=ORIENTED_EDGE('',*,*,#1002,.F.);
#1052=EDGE_CURVE('E788',#999,#489,#1016,.T.);
#1053=ORIENTED_EDGE('',*,*,#1052,.T.);
#1054=ORIENTED_EDGE('',*,*,#490,.T.);
#1055=DIRECTION('',(1.,0.,0.));
#1056=VECTOR('',#1055,1.);
#1057=CARTESIAN_POINT('',(0.,12.7,139.7));
#1058=LINE('',#1057,#1056);
#1059=EDGE_CURVE('E784',#328,#481,#1058,.T.);
#1060=ORIENTED_EDGE('',*,*,#1059,.F.);
#1061=ORIENTED_EDGE('',*,*,#329,.F.);
#1062=ORIENTED_EDGE('',*,*,#437,.F.);
#1063=ORIENTED_EDGE('',*,*,#305,.T.);
#1064=DIRECTION('',(1.,0.,0.));
#1065=VECTOR('',#1064,1.);
#1066=CARTESIAN_POINT('',(12.7,12.7,139.7));
#1067=LINE('',#1066,#1065);
#1068=CARTESIAN_POINT('',(38.1,12.7,139.7));
#1069=VERTEX_POINT('',#1068);
#1070=EDGE_CURVE('E903',#296,#1069,#1067,.T.);
#1071=ORIENTED_EDGE('',*,*,#1070,.T.);
#1072=DIRECTION('',(0.,1.,0.));
#1073=VECTOR('',#1072,1.);
#1074=CARTESIAN_POINT('',(38.1,0.,139.7));
#1075=LINE('',#1074,#1073);
#1076=CARTESIAN_POINT('',(38.1,30.3,139.7));
#1077=VERTEX_POINT('',#1076);
#1078=EDGE_CURVE('E906',#1069,#1077,#1075,.T.);
#1079=ORIENTED_EDGE('',*,*,#1078,.T.);
#1080=DIRECTION('',(-1.,0.,0.));
#1081=VECTOR('',#1080,1.);
#1082=CARTESIAN_POINT('',(12.7,30.3,139.7));
#1083=LINE('',#1082,#1081);
#1084=CARTESIAN_POINT('',(12.7,30.3,139.7));
#1085=VERTEX_POINT('',#1084);
#1086=EDGE_CURVE('E909',#1077,#1085,#1083,.T.);
#1087=ORIENTED_EDGE('',*,*,#1086,.T.);
#1088=DIRECTION('',(0.,-1.,0.));
#1089=VECTOR('',#1088,1.);
#1090=CARTESIAN_POINT('',(12.7,0.,139.7));
#1091=LINE('',#1090,#1089);
#1092=EDGE_CURVE('E510',#1085,#296,#1091,.T.);
#1093=ORIENTED_EDGE('',*,*,#1092,.T.);
#1094=EDGE_CURVE('E780',#368,#296,#1058,.T.);
#1095=ORIENTED_EDGE('',*,*,#1094,.F.);
#1096=ORIENTED_EDGE('',*,*,#369,.F.);
#1097=EDGE_LOOP('',(#1018,#1026,#1034,#1042,#1048,#1049,#1050,#1051,#1053,#1054,#1060,#1061,
#1062,#1063,#1071,#1079,#1087,#1093,#1095,#1096));
#1098=FACE_BOUND('',#1097,.T.);
#1099=DIRECTION('',(-1.,0.,0.));
#1100=VECTOR('',#1099,1.);
#1101=CARTESIAN_POINT('',(12.7,70.,139.7));
#1102=LINE('',#1101,#1100);
#1103=CARTESIAN_POINT('',(45.925,70.,139.7));
#1104=VERTEX_POINT('',#1103);
#1105=CARTESIAN_POINT('',(30.275,70.,139.7));
#1106=VERTEX_POINT('',#1105);
#1107=EDGE_CURVE('E897',#1104,#1106,#1102,.T.);
#1108=ORIENTED_EDGE('',*,*,#1107,.T.);
#1109=DIRECTION('',(0.,-1.,0.));
#1110=VECTOR('',#1109,1.);
#1111=CARTESIAN_POINT('',(30.275,0.,139.7));
#1112=LINE('',#1111,#1110);
#1113=CARTESIAN_POINT('',(30.275,43.,139.7));
#1114=VERTEX_POINT('',#1113);
#1115=EDGE_CURVE('E900',#1106,#1114,#1112,.T.);
#1116=ORIENTED_EDGE('',*,*,#1115,.T.);
#1117=DIRECTION('',(1.,0.,0.));
#1118=VECTOR('',#1117,1.);
#1119=CARTESIAN_POINT('',(12.7,43.,139.7));
#1120=LINE('',#1119,#1118);
#1121=CARTESIAN_POINT('',(45.925,43.,139.7));
#1122=VERTEX_POINT('',#1121);
#1123=EDGE_CURVE('E889',#1114,#1122,#1120,.T.);
#1124=ORIENTED_EDGE('',*,*,#1123,.T.);
#1125=DIRECTION('',(0.,1.,0.));
#1126=VECTOR('',#1125,1.);
#1127=CARTESIAN_POINT('',(45.925,0.,139.7));
#1128=LINE('',#1127,#1126);
#1129=EDGE_CURVE('E894',#1122,#1104,#1128,.T.);
#1130=ORIENTED_EDGE('',*,*,#1129,.T.);
#1131=EDGE_LOOP('',(#1108,#1116,#1124,#1130));
#1132=FACE_BOUND('',#1131,.T.);
#1133=CARTESIAN_POINT('',(57.15,25.4,139.7));
#1134=DIRECTION('',(0.,0.,1.));
#1135=DIRECTION('',(1.,0.,0.));
#1136=AXIS2_PLACEMENT_3D('',#1133,#1134,#1135);
#1137=CIRCLE('',#1136,6.35);
#1138=CARTESIAN_POINT('',(63.5,25.4,139.7));
#1139=VERTEX_POINT('',#1138);
#1140=EDGE_CURVE('E619',#1139,#1139,#1137,.T.);
#1141=ORIENTED_EDGE('',*,*,#1140,.T.);
#1142=EDGE_LOOP('',(#1141));
#1143=FACE_BOUND('',#1142,.T.);
#1144=DIRECTION('',(0.,1.,0.));
#1145=VECTOR('',#1144,1.);
#1146=CARTESIAN_POINT('',(63.5,0.,139.7));
#1147=LINE('',#1146,#1145);
#1148=CARTESIAN_POINT('',(63.5,82.55,139.7));
#1149=VERTEX_POINT('',#1148);
#1150=CARTESIAN_POINT('',(63.5,127.,139.7));
#1151=VERTEX_POINT('',#1150);
#1152=EDGE_CURVE('E883',#1149,#1151,#1147,.T.);
#1153=ORIENTED_EDGE('',*,*,#1152,.T.);
#1154=CARTESIAN_POINT('',(57.15,127.,139.7));
#1155=DIRECTION('',(0.,0.,1.));
#1156=DIRECTION('',(1.,0.,0.));
#1157=AXIS2_PLACEMENT_3D('',#1154,#1155,#1156);
#1158=CIRCLE('',#1157,6.34999999999999);
#1159=CARTESIAN_POINT('',(50.8,127.,139.7));
#1160=VERTEX_POINT('',#1159);
#1161=EDGE_CURVE('E886',#1151,#1160,#1158,.T.);
#1162=ORIENTED_EDGE('',*,*,#1161,.T.);
#1163=DIRECTION('',(0.,-1.,0.));
#1164=VECTOR('',#1163,1.);
#1165=CARTESIAN_POINT('',(50.8,0.,139.7));
#1166=LINE('',#1165,#1164);
#1167=CARTESIAN_POINT('',(50.8,82.55,139.7));
#1168=VERTEX_POINT('',#1167);
#1169=EDGE_CURVE('E877',#1160,#1168,#1166,.T.);
#1170=ORIENTED_EDGE('',*,*,#1169,.T.);
#1171=CARTESIAN_POINT('',(57.15,82.55,139.7));
#1172=DIRECTION('',(0.,0.,1.));
#1173=DIRECTION('',(1.,0.,0.));
#1174=AXIS2_PLACEMENT_3D('',#1171,#1172,#1173);
#1175=CIRCLE('',#1174,6.34999999999999);
#1176=EDGE_CURVE('E880',#1168,#1149,#1175,.T.);
#1177=ORIENTED_EDGE('',*,*,#1176,.T.);
#1178=EDGE_LOOP('',(#1153,#1162,#1170,#1177));
#1179=FACE_BOUND('',#1178,.T.);
#1180=ADVANCED_FACE('F914',(#1098,#1132,#1143,#1179),#1012,.F.);
#1181=CARTESIAN_POINT('',(0.,139.7,139.7));
#1182=DIRECTION('',(0.,1.,0.));
#1183=DIRECTION('',(0.,0.,1.));
#1184=AXIS2_PLACEMENT_3D('',#1181,#1182,#1183);
#1185=PLANE('',#1184);
#1186=ORIENTED_EDGE('',*,*,#970,.T.);
#1187=ORIENTED_EDGE('',*,*,#496,.T.);
#1188=ORIENTED_EDGE('',*,*,#1052,.F.);
#1189=ORIENTED_EDGE('',*,*,#1000,.F.);
#1190=EDGE_LOOP('',(#1186,#1187,#1188,#1189));
#1191=FACE_BOUND('',#1190,.T.);
#1192=ADVANCED_FACE('F1068',(#1191),#1185,.F.);
#1193=CARTESIAN_POINT('',(0.,12.7,139.7));
#1194=DIRECTION('',(0.,-1.,0.));
#1195=DIRECTION('',(0.,0.,-1.));
#1196=AXIS2_PLACEMENT_3D('',#1193,#1194,#1195);
#1197=PLANE('',#1196);
#1198=ORIENTED_EDGE('',*,*,#1059,.T.);
#1199=ORIENTED_EDGE('',*,*,#482,.T.);
#1200=ORIENTED_EDGE('',*,*,#965,.F.);
#1201=ORIENTED_EDGE('',*,*,#337,.F.);
#1202=EDGE_LOOP('',(#1198,#1199,#1200,#1201));
#1203=FACE_BOUND('',#1202,.T.);
#1204=ADVANCED_FACE('F1071',(#1203),#1197,.F.);
#1205=ORIENTED_EDGE('',*,*,#930,.F.);
#1206=ORIENTED_EDGE('',*,*,#377,.F.);
#1207=ORIENTED_EDGE('',*,*,#1094,.T.);
#1208=ORIENTED_EDGE('',*,*,#297,.F.);
#1209=EDGE_LOOP('',(#1205,#1206,#1207,#1208));
#1210=FACE_BOUND('',#1209,.T.);
#1211=ADVANCED_FACE('F937',(#1210),#1197,.F.);
#1212=ORIENTED_EDGE('',*,*,#1017,.F.);
#1213=ORIENTED_EDGE('',*,*,#391,.F.);
#1214=ORIENTED_EDGE('',*,*,#923,.T.);
#1215=ORIENTED_EDGE('',*,*,#809,.F.);
#1216=EDGE_LOOP('',(#1212,#1213,#1214,#1215));
#1217=FACE_BOUND('',#1216,.T.);
#1218=ADVANCED_FACE('F1063',(#1217),#1185,.F.);
#1219=CARTESIAN_POINT('',(10.575,70.,177.8));
#1220=DIRECTION('',(1.,0.,0.));
#1221=DIRECTION('',(0.,1.,0.));
#1222=AXIS2_PLACEMENT_3D('',#1219,#1220,#1221);
#1223=PLANE('',#1222);
#1224=ORIENTED_EDGE('',*,*,#181,.T.);
#1225=DIRECTION('',(0.,0.,-1.));
#1226=VECTOR('',#1225,1.);
#1227=CARTESIAN_POINT('',(10.575,43.,177.8));
#1228=LINE('',#1227,#1226);
#1229=CARTESIAN_POINT('',(10.575,43.,177.8));
#1230=VERTEX_POINT('',#1229);
#1231=EDGE_CURVE('E753',#1230,#180,#1228,.T.);
#1232=ORIENTED_EDGE('',*,*,#1231,.F.);
#1233=DIRECTION('',(0.,-1.,0.));
#1234=VECTOR('',#1233,1.);
#1235=CARTESIAN_POINT('',(10.575,70.,177.8));
#1236=LINE('',#1235,#1234);
#1237=CARTESIAN_POINT('',(10.575,70.,177.8));
#1238=VERTEX_POINT('',#1237);
#1239=EDGE_CURVE('E724',#1238,#1230,#1236,.T.);
#1240=ORIENTED_EDGE('',*,*,#1239,.F.);
#1241=DIRECTION('',(0.,0.,-1.));
#1242=VECTOR('',#1241,1.);
#1243=CARTESIAN_POINT('',(10.575,70.,177.8));
#1244=LINE('',#1243,#1242);
#1245=EDGE_CURVE('E734',#1238,#178,#1244,.T.);
#1246=ORIENTED_EDGE('',*,*,#1245,.T.);
#1247=EDGE_LOOP('',(#1224,#1232,#1240,#1246));
#1248=FACE_BOUND('',#1247,.T.);
#1249=ADVANCED_FACE('F1059',(#1248),#1223,.F.);
#1250=CARTESIAN_POINT('',(10.575,43.,177.8));
#1251=DIRECTION('',(0.,1.,0.));
#1252=DIRECTION('',(0.,0.,1.));
#1253=AXIS2_PLACEMENT_3D('',#1250,#1251,#1252);
#1254=PLANE('',#1253);
#1255=ORIENTED_EDGE('',*,*,#203,.T.);
#1256=DIRECTION('',(0.,0.,-1.));
#1257=VECTOR('',#1256,1.);
#1258=CARTESIAN_POINT('',(17.575,43.,177.8));
#1259=LINE('',#1258,#1257);
#1260=CARTESIAN_POINT('',(17.575,43.,177.8));
#1261=VERTEX_POINT('',#1260);
#1262=EDGE_CURVE('E750',#1261,#196,#1259,.T.);
#1263=ORIENTED_EDGE('',*,*,#1262,.F.);
#1264=DIRECTION('',(1.,0.,0.));
#1265=VECTOR('',#1264,1.);
#1266=CARTESIAN_POINT('',(10.575,43.,177.8));
#1267=LINE('',#1266,#1265);
#1268=EDGE_CURVE('E727',#1230,#1261,#1267,.T.);
#1269=ORIENTED_EDGE('',*,*,#1268,.F.);
#1270=ORIENTED_EDGE('',*,*,#1231,.T.);
#1271=EDGE_LOOP('',(#1255,#1263,#1269,#1270));
#1272=FACE_BOUND('',#1271,.T.);
#1273=ADVANCED_FACE('F1055',(#1272),#1254,.F.);
#1274=CARTESIAN_POINT('',(17.575,70.,177.8));
#1275=DIRECTION('',(-1.,0.,0.));
#1276=DIRECTION('',(0.,-1.,0.));
#1277=AXIS2_PLACEMENT_3D('',#1274,#1275,#1276);
#1278=PLANE('',#1277);
#1279=ORIENTED_EDGE('',*,*,#197,.T.);
#1280=DIRECTION('',(0.,0.,-1.));
#1281=VECTOR('',#1280,1.);
#1282=CARTESIAN_POINT('',(17.575,70.,177.8));
#1283=LINE('',#1282,#1281);
#1284=CARTESIAN_POINT('',(17.575,70.,177.8));
#1285=VERTEX_POINT('',#1284);
#1286=EDGE_CURVE('E747',#1285,#188,#1283,.T.);
#1287=ORIENTED_EDGE('',*,*,#1286,.F.);
#1288=DIRECTION('',(0.,1.,0.));
#1289=VECTOR('',#1288,1.);
#1290=CARTESIAN_POINT('',(17.575,70.,177.8));
#1291=LINE('',#1290,#1289);
#1292=EDGE_CURVE('E730',#1261,#1285,#1291,.T.);
#1293=ORIENTED_EDGE('',*,*,#1292,.F.);
#1294=ORIENTED_EDGE('',*,*,#1262,.T.);
#1295=EDGE_LOOP('',(#1279,#1287,#1293,#1294));
#1296=FACE_BOUND('',#1295,.T.);
#1297=ADVANCED_FACE('F1051',(#1296),#1278,.F.);
#1298=CARTESIAN_POINT('',(10.575,70.,177.8));
#1299=DIRECTION('',(0.,-1.,0.));
#1300=DIRECTION('',(1.,0.,0.));
#1301=AXIS2_PLACEMENT_3D('',#1298,#1299,#1300);
#1302=PLANE('',#1301);
#1303=ORIENTED_EDGE('',*,*,#189,.T.);
#1304=ORIENTED_EDGE('',*,*,#1245,.F.);
#1305=DIRECTION('',(-1.,0.,0.));
#1306=VECTOR('',#1305,1.);
#1307=CARTESIAN_POINT('',(10.575,70.,177.8));
#1308=LINE('',#1307,#1306);
#1309=EDGE_CURVE('E732',#1285,#1238,#1308,.T.);
#1310=ORIENTED_EDGE('',*,*,#1309,.F.);
#1311=ORIENTED_EDGE('',*,*,#1286,.T.);
#1312=EDGE_LOOP('',(#1303,#1304,#1310,#1311));
#1313=FACE_BOUND('',#1312,.T.);
#1314=ADVANCED_FACE('F1047',(#1313),#1302,.F.);
#1315=CARTESIAN_POINT('',(0.,0.,177.8));
#1316=DIRECTION('',(0.,0.,1.));
#1317=DIRECTION('',(1.,0.,0.));
#1318=AXIS2_PLACEMENT_3D('',#1315,#1316,#1317);
#1319=PLANE('',#1318);
#1320=ORIENTED_EDGE('',*,*,#1239,.T.);
#1321=ORIENTED_EDGE('',*,*,#1268,.T.);
#1322=ORIENTED_EDGE('',*,*,#1292,.T.);
#1323=ORIENTED_EDGE('',*,*,#1309,.T.);
#1324=EDGE_LOOP('',(#1320,#1321,#1322,#1323));
#1325=FACE_BOUND('',#1324,.T.);
#1326=ADVANCED_FACE('F1041',(#1325),#1319,.T.);
#1327=CARTESIAN_POINT('',(58.625,70.,177.8));
#1328=DIRECTION('',(1.,0.,0.));
#1329=DIRECTION('',(0.,0.,-1.));
#1330=AXIS2_PLACEMENT_3D('',#1327,#1328,#1329);
#1331=PLANE('',#1330);
#1332=ORIENTED_EDGE('',*,*,#249,.T.);
#1333=DIRECTION('',(0.,0.,-1.));
#1334=VECTOR('',#1333,1.);
#1335=CARTESIAN_POINT('',(58.625,43.,177.8));
#1336=LINE('',#1335,#1334);
#1337=CARTESIAN_POINT('',(58.625,43.,177.8));
#1338=VERTEX_POINT('',#1337);
#1339=EDGE_CURVE('E720',#1338,#248,#1336,.T.);
#1340=ORIENTED_EDGE('',*,*,#1339,.F.);
#1341=DIRECTION('',(0.,-1.,0.));
#1342=VECTOR('',#1341,1.);
#1343=CARTESIAN_POINT('',(58.625,70.,177.8));
#1344=LINE('',#1343,#1342);
#1345=CARTESIAN_POINT('',(58.625,70.,177.8));
#1346=VERTEX_POINT('',#1345);
#1347=EDGE_CURVE('E691',#1346,#1338,#1344,.T.);
#1348=ORIENTED_EDGE('',*,*,#1347,.F.);
#1349=DIRECTION('',(0.,0.,-1.));
#1350=VECTOR('',#1349,1.);
#1351=CARTESIAN_POINT('',(58.625,70.,177.8));
#1352=LINE('',#1351,#1350);
#1353=EDGE_CURVE('E701',#1346,#246,#1352,.T.);
#1354=ORIENTED_EDGE('',*,*,#1353,.T.);
#1355=EDGE_LOOP('',(#1332,#1340,#1348,#1354));
#1356=FACE_BOUND('',#1355,.T.);
#1357=ADVANCED_FACE('F1025',(#1356),#1331,.F.);
#1358=CARTESIAN_POINT('',(58.625,43.,177.8));
#1359=DIRECTION('',(0.,1.,0.));
#1360=DIRECTION('',(0.,0.,1.));
#1361=AXIS2_PLACEMENT_3D('',#1358,#1359,#1360);
#1362=PLANE('',#1361);
#1363=ORIENTED_EDGE('',*,*,#271,.T.);
#1364=DIRECTION('',(0.,0.,-1.));
#1365=VECTOR('',#1364,1.);
#1366=CARTESIAN_POINT('',(65.625,43.,177.8));
#1367=LINE('',#1366,#1365);
#1368=CARTESIAN_POINT('',(65.625,43.,177.8));
#1369=VERTEX_POINT('',#1368);
#1370=EDGE_CURVE('E717',#1369,#264,#1367,.T.);
#1371=ORIENTED_EDGE('',*,*,#1370,.F.);
#1372=DIRECTION('',(1.,0.,0.));
#1373=VECTOR('',#1372,1.);
#1374=CARTESIAN_POINT('',(58.625,43.,177.8));
#1375=LINE('',#1374,#1373);
#1376=EDGE_CURVE('E694',#1338,#1369,#1375,.T.);
#1377=ORIENTED_EDGE('',*,*,#1376,.F.);
#1378=ORIENTED_EDGE('',*,*,#1339,.T.);
#1379=EDGE_LOOP('',(#1363,#1371,#1377,#1378));
#1380=FACE_BOUND('',#1379,.T.);
#1381=ADVANCED_FACE('F1033',(#1380),#1362,.F.);
#1382=CARTESIAN_POINT('',(65.625,70.,177.8));
#1383=DIRECTION('',(-1.,0.,0.));
#1384=DIRECTION('',(0.,0.,1.));
#1385=AXIS2_PLACEMENT_3D('',#1382,#1383,#1384);
#1386=PLANE('',#1385);
#1387=ORIENTED_EDGE('',*,*,#265,.T.);
#1388=DIRECTION('',(0.,0.,-1.));
#1389=VECTOR('',#1388,1.);
#1390=CARTESIAN_POINT('',(65.625,70.,177.8));
#1391=LINE('',#1390,#1389);
#1392=CARTESIAN_POINT('',(65.625,70.,177.8));
#1393=VERTEX_POINT('',#1392);
#1394=EDGE_CURVE('E714',#1393,#256,#1391,.T.);
#1395=ORIENTED_EDGE('',*,*,#1394,.F.);
#1396=DIRECTION('',(0.,1.,0.));
#1397=VECTOR('',#1396,1.);
#1398=CARTESIAN_POINT('',(65.625,70.,177.8));
#1399=LINE('',#1398,#1397);
#1400=EDGE_CURVE('E697',#1369,#1393,#1399,.T.);
#1401=ORIENTED_EDGE('',*,*,#1400,.F.);
#1402=ORIENTED_EDGE('',*,*,#1370,.T.);
#1403=EDGE_LOOP('',(#1387,#1395,#1401,#1402));
#1404=FACE_BOUND('',#1403,.T.);
#1405=ADVANCED_FACE('F1031',(#1404),#1386,.F.);
#1406=CARTESIAN_POINT('',(58.625,70.,177.8));
#1407=DIRECTION('',(0.,-1.,0.));
#1408=DIRECTION('',(1.,0.,0.));
#1409=AXIS2_PLACEMENT_3D('',#1406,#1407,#1408);
#1410=PLANE('',#1409);
#1411=ORIENTED_EDGE('',*,*,#257,.T.);
#1412=ORIENTED_EDGE('',*,*,#1353,.F.);
#1413=DIRECTION('',(-1.,0.,0.));
#1414=VECTOR('',#1413,1.);
#1415=CARTESIAN_POINT('',(58.625,70.,177.8));
#1416=LINE('',#1415,#1414);
#1417=EDGE_CURVE('E699',#1393,#1346,#1416,.T.);
#1418=ORIENTED_EDGE('',*,*,#1417,.F.);
#1419=ORIENTED_EDGE('',*,*,#1394,.T.);
#1420=EDGE_LOOP('',(#1411,#1412,#1418,#1419));
#1421=FACE_BOUND('',#1420,.T.);
#1422=ADVANCED_FACE('F1021',(#1421),#1410,.F.);
#1423=CARTESIAN_POINT('',(0.,0.,177.8));
#1424=DIRECTION('',(0.,0.,1.));
#1425=DIRECTION('',(1.,0.,0.));
#1426=AXIS2_PLACEMENT_3D('',#1423,#1424,#1425);
#1427=PLANE('',#1426);
#1428=ORIENTED_EDGE('',*,*,#1347,.T.);
#1429=ORIENTED_EDGE('',*,*,#1376,.T.);
#1430=ORIENTED_EDGE('',*,*,#1400,.T.);
#1431=ORIENTED_EDGE('',*,*,#1417,.T.);
#1432=EDGE_LOOP('',(#1428,#1429,#1430,#1431));
#1433=FACE_BOUND('',#1432,.T.);
#1434=ADVANCED_FACE('F1027',(#1433),#1427,.T.);
#1435=CARTESIAN_POINT('',(10.575,70.,-25.4));
#1436=DIRECTION('',(-1.,0.,0.));
#1437=DIRECTION('',(0.,-1.,0.));
#1438=AXIS2_PLACEMENT_3D('',#1435,#1436,#1437);
#1439=PLANE('',#1438);
#1440=ORIENTED_EDGE('',*,*,#766,.F.);
#1441=DIRECTION('',(0.,0.,1.));
#1442=VECTOR('',#1441,1.);
#1443=CARTESIAN_POINT('',(10.575,70.,-25.4));
#1444=LINE('',#1443,#1442);
#1445=CARTESIAN_POINT('',(10.575,70.,-25.4));
#1446=VERTEX_POINT('',#1445);
#1447=EDGE_CURVE('E687',#1446,#763,#1444,.T.);
#1448=ORIENTED_EDGE('',*,*,#1447,.F.);
#1449=DIRECTION('',(0.,-1.,0.));
#1450=VECTOR('',#1449,1.);
#1451=CARTESIAN_POINT('',(10.575,70.,-25.4));
#1452=LINE('',#1451,#1450);
#1453=CARTESIAN_POINT('',(10.575,43.,-25.4));
#1454=VERTEX_POINT('',#1453);
#1455=EDGE_CURVE('E659',#1446,#1454,#1452,.T.);
#1456=ORIENTED_EDGE('',*,*,#1455,.T.);
#1457=DIRECTION('',(0.,0.,1.));
#1458=VECTOR('',#1457,1.);
#1459=CARTESIAN_POINT('',(10.575,43.,-25.4));
#1460=LINE('',#1459,#1458);
#1461=EDGE_CURVE('E672',#1454,#765,#1460,.T.);
#1462=ORIENTED_EDGE('',*,*,#1461,.T.);
#1463=EDGE_LOOP('',(#1440,#1448,#1456,#1462));
#1464=FACE_BOUND('',#1463,.T.);
#1465=ADVANCED_FACE('F1271',(#1464),#1439,.T.);
#1466=CARTESIAN_POINT('',(10.575,70.,-25.4));
#1467=DIRECTION('',(0.,1.,0.));
#1468=DIRECTION('',(-1.,0.,0.));
#1469=AXIS2_PLACEMENT_3D('',#1466,#1467,#1468);
#1470=PLANE('',#1469);
#1471=ORIENTED_EDGE('',*,*,#788,.F.);
#1472=DIRECTION('',(0.,0.,1.));
#1473=VECTOR('',#1472,1.);
#1474=CARTESIAN_POINT('',(17.575,70.,-25.4));
#1475=LINE('',#1474,#1473);
#1476=CARTESIAN_POINT('',(17.575,70.,-25.4));
#1477=VERTEX_POINT('',#1476);
#1478=EDGE_CURVE('E684',#1477,#781,#1475,.T.);
#1479=ORIENTED_EDGE('',*,*,#1478,.F.);
#1480=DIRECTION('',(-1.,0.,0.));
#1481=VECTOR('',#1480,1.);
#1482=CARTESIAN_POINT('',(10.575,70.,-25.4));
#1483=LINE('',#1482,#1481);
#1484=EDGE_CURVE('E662',#1477,#1446,#1483,.T.);
#1485=ORIENTED_EDGE('',*,*,#1484,.T.);
#1486=ORIENTED_EDGE('',*,*,#1447,.T.);
#1487=EDGE_LOOP('',(#1471,#1479,#1485,#1486));
#1488=FACE_BOUND('',#1487,.T.);
#1489=ADVANCED_FACE('F1280',(#1488),#1470,.T.);
#1490=CARTESIAN_POINT('',(17.575,70.,-25.4));
#1491=DIRECTION('',(1.,0.,0.));
#1492=DIRECTION('',(0.,1.,0.));
#1493=AXIS2_PLACEMENT_3D('',#1490,#1491,#1492);
#1494=PLANE('',#1493);
#1495=ORIENTED_EDGE('',*,*,#782,.F.);
#1496=DIRECTION('',(0.,0.,1.));
#1497=VECTOR('',#1496,1.);
#1498=CARTESIAN_POINT('',(17.575,43.,-25.4));
#1499=LINE('',#1498,#1497);
#1500=CARTESIAN_POINT('',(17.575,43.,-25.4));
#1501=VERTEX_POINT('',#1500);
#1502=EDGE_CURVE('E681',#1501,#773,#1499,.T.);
#1503=ORIENTED_EDGE('',*,*,#1502,.F.);
#1504=DIRECTION('',(0.,1.,0.));
#1505=VECTOR('',#1504,1.);
#1506=CARTESIAN_POINT('',(17.575,70.,-25.4));
#1507=LINE('',#1506,#1505);
#1508=EDGE_CURVE('E666',#1501,#1477,#1507,.T.);
#1509=ORIENTED_EDGE('',*,*,#1508,.T.);
#1510=ORIENTED_EDGE('',*,*,#1478,.T.);
#1511=EDGE_LOOP('',(#1495,#1503,#1509,#1510));
#1512=FACE_BOUND('',#1511,.T.);
#1513=ADVANCED_FACE('F1290',(#1512),#1494,.T.);
#1514=CARTESIAN_POINT('',(10.575,43.,-25.4));
#1515=DIRECTION('',(0.,-1.,0.));
#1516=DIRECTION('',(0.,0.,-1.));
#1517=AXIS2_PLACEMENT_3D('',#1514,#1515,#1516);
#1518=PLANE('',#1517);
#1519=ORIENTED_EDGE('',*,*,#774,.F.);
#1520=ORIENTED_EDGE('',*,*,#1461,.F.);
#1521=DIRECTION('',(1.,0.,0.));
#1522=VECTOR('',#1521,1.);
#1523=CARTESIAN_POINT('',(10.575,43.,-25.4));
#1524=LINE('',#1523,#1522);
#1525=EDGE_CURVE('E669',#1454,#1501,#1524,.T.);
#1526=ORIENTED_EDGE('',*,*,#1525,.T.);
#1527=ORIENTED_EDGE('',*,*,#1502,.T.);
#1528=EDGE_LOOP('',(#1519,#1520,#1526,#1527));
#1529=FACE_BOUND('',#1528,.T.);
#1530=ADVANCED_FACE('F1300',(#1529),#1518,.T.);
#1531=CARTESIAN_POINT('',(0.,0.,-25.4));
#1532=DIRECTION('',(0.,0.,-1.));
#1533=DIRECTION('',(1.,0.,0.));
#1534=AXIS2_PLACEMENT_3D('',#1531,#1532,#1533);
#1535=PLANE('',#1534);
#1536=ORIENTED_EDGE('',*,*,#1455,.F.);
#1537=ORIENTED_EDGE('',*,*,#1484,.F.);
#1538=ORIENTED_EDGE('',*,*,#1508,.F.);
#1539=ORIENTED_EDGE('',*,*,#1525,.F.);
#1540=EDGE_LOOP('',(#1536,#1537,#1538,#1539));
#1541=FACE_BOUND('',#1540,.T.);
#1542=ADVANCED_FACE('F1310',(#1541),#1535,.T.);
#1543=CARTESIAN_POINT('',(58.625,70.,-25.4));
#1544=DIRECTION('',(-1.,0.,0.));
#1545=DIRECTION('',(0.,0.,1.));
#1546=AXIS2_PLACEMENT_3D('',#1543,#1544,#1545);
#1547=PLANE('',#1546);
#1548=ORIENTED_EDGE('',*,*,#732,.F.);
#1549=DIRECTION('',(0.,0.,1.));
#1550=VECTOR('',#1549,1.);
#1551=CARTESIAN_POINT('',(58.625,70.,-25.4));
#1552=LINE('',#1551,#1550);
#1553=CARTESIAN_POINT('',(58.625,70.,-25.4));
#1554=VERTEX_POINT('',#1553);
#1555=EDGE_CURVE('E655',#1554,#729,#1552,.T.);
#1556=ORIENTED_EDGE('',*,*,#1555,.F.);
#1557=DIRECTION('',(0.,-1.,0.));
#1558=VECTOR('',#1557,1.);
#1559=CARTESIAN_POINT('',(58.625,70.,-25.4));
#1560=LINE('',#1559,#1558);
#1561=CARTESIAN_POINT('',(58.625,43.,-25.4));
#1562=VERTEX_POINT('',#1561);
#1563=EDGE_CURVE('E627',#1554,#1562,#1560,.T.);
#1564=ORIENTED_EDGE('',*,*,#1563,.T.);
#1565=DIRECTION('',(0.,0.,1.));
#1566=VECTOR('',#1565,1.);
#1567=CARTESIAN_POINT('',(58.625,43.,-25.4));
#1568=LINE('',#1567,#1566);
#1569=EDGE_CURVE('E640',#1562,#731,#1568,.T.);
#1570=ORIENTED_EDGE('',*,*,#1569,.T.);
#1571=EDGE_LOOP('',(#1548,#1556,#1564,#1570));
#1572=FACE_BOUND('',#1571,.T.);
#1573=ADVANCED_FACE('F1320',(#1572),#1547,.T.);
#1574=CARTESIAN_POINT('',(58.625,70.,-25.4));
#1575=DIRECTION('',(0.,1.,0.));
#1576=DIRECTION('',(-1.,0.,0.));
#1577=AXIS2_PLACEMENT_3D('',#1574,#1575,#1576);
#1578=PLANE('',#1577);
#1579=ORIENTED_EDGE('',*,*,#754,.F.);
#1580=DIRECTION('',(0.,0.,1.));
#1581=VECTOR('',#1580,1.);
#1582=CARTESIAN_POINT('',(65.625,70.,-25.4));
#1583=LINE('',#1582,#1581);
#1584=CARTESIAN_POINT('',(65.625,70.,-25.4));
#1585=VERTEX_POINT('',#1584);
#1586=EDGE_CURVE('E652',#1585,#747,#1583,.T.);
#1587=ORIENTED_EDGE('',*,*,#1586,.F.);
#1588=DIRECTION('',(-1.,0.,0.));
#1589=VECTOR('',#1588,1.);
#1590=CARTESIAN_POINT('',(58.625,70.,-25.4));
#1591=LINE('',#1590,#1589);
#1592=EDGE_CURVE('E630',#1585,#1554,#1591,.T.);
#1593=ORIENTED_EDGE('',*,*,#1592,.T.);
#1594=ORIENTED_EDGE('',*,*,#1555,.T.);
#1595=EDGE_LOOP('',(#1579,#1587,#1593,#1594));
#1596=FACE_BOUND('',#1595,.T.);
#1597=ADVANCED_FACE('F1330',(#1596),#1578,.T.);
#1598=CARTESIAN_POINT('',(65.625,70.,-25.4));
#1599=DIRECTION('',(1.,0.,0.));
#1600=DIRECTION('',(0.,0.,-1.));
#1601=AXIS2_PLACEMENT_3D('',#1598,#1599,#1600);
#1602=PLANE('',#1601);
#1603=ORIENTED_EDGE('',*,*,#748,.F.);
#1604=DIRECTION('',(0.,0.,1.));
#1605=VECTOR('',#1604,1.);
#1606=CARTESIAN_POINT('',(65.625,43.,-25.4));
#1607=LINE('',#1606,#1605);
#1608=CARTESIAN_POINT('',(65.625,43.,-25.4));
#1609=VERTEX_POINT('',#1608);
#1610=EDGE_CURVE('E649',#1609,#739,#1607,.T.);
#1611=ORIENTED_EDGE('',*,*,#1610,.F.);
#1612=DIRECTION('',(0.,1.,0.));
#1613=VECTOR('',#1612,1.);
#1614=CARTESIAN_POINT('',(65.625,70.,-25.4));
#1615=LINE('',#1614,#1613);
#1616=EDGE_CURVE('E634',#1609,#1585,#1615,.T.);
#1617=ORIENTED_EDGE('',*,*,#1616,.T.);
#1618=ORIENTED_EDGE('',*,*,#1586,.T.);
#1619=EDGE_LOOP('',(#1603,#1611,#1617,#1618));
#1620=FACE_BOUND('',#1619,.T.);
#1621=ADVANCED_FACE('F1340',(#1620),#1602,.T.);
#1622=CARTESIAN_POINT('',(58.625,43.,-25.4));
#1623=DIRECTION('',(0.,-1.,0.));
#1624=DIRECTION('',(0.,0.,-1.));
#1625=AXIS2_PLACEMENT_3D('',#1622,#1623,#1624);
#1626=PLANE('',#1625);
#1627=ORIENTED_EDGE('',*,*,#740,.F.);
#1628=ORIENTED_EDGE('',*,*,#1569,.F.);
#1629=DIRECTION('',(1.,0.,0.));
#1630=VECTOR('',#1629,1.);
#1631=CARTESIAN_POINT('',(58.625,43.,-25.4));
#1632=LINE('',#1631,#1630);
#1633=EDGE_CURVE('E637',#1562,#1609,#1632,.T.);
#1634=ORIENTED_EDGE('',*,*,#1633,.T.);
#1635=ORIENTED_EDGE('',*,*,#1610,.T.);
#1636=EDGE_LOOP('',(#1627,#1628,#1634,#1635));
#1637=FACE_BOUND('',#1636,.T.);
#1638=ADVANCED_FACE('F1350',(#1637),#1626,.T.);
#1639=CARTESIAN_POINT('',(0.,0.,-25.4));
#1640=DIRECTION('',(0.,0.,-1.));
#1641=DIRECTION('',(1.,0.,0.));
#1642=AXIS2_PLACEMENT_3D('',#1639,#1640,#1641);
#1643=PLANE('',#1642);
#1644=ORIENTED_EDGE('',*,*,#1563,.F.);
#1645=ORIENTED_EDGE('',*,*,#1592,.F.);
#1646=ORIENTED_EDGE('',*,*,#1616,.F.);
#1647=ORIENTED_EDGE('',*,*,#1633,.F.);
#1648=EDGE_LOOP('',(#1644,#1645,#1646,#1647));
#1649=FACE_BOUND('',#1648,.T.);
#1650=ADVANCED_FACE('F1360',(#1649),#1643,.T.);
#1651=CARTESIAN_POINT('',(50.8,127.,-25.4));
#1652=DIRECTION('',(-1.,0.,0.));
#1653=DIRECTION('',(0.,0.,1.));
#1654=AXIS2_PLACEMENT_3D('',#1651,#1652,#1653);
#1655=PLANE('',#1654);
#1656=DIRECTION('',(0.,0.,1.));
#1657=VECTOR('',#1656,1.);
#1658=CARTESIAN_POINT('',(50.8,127.,-25.4));
#1659=LINE('',#1658,#1657);
#1660=EDGE_CURVE('E587',#1160,#142,#1659,.T.);
#1661=ORIENTED_EDGE('',*,*,#1660,.T.);
#1662=ORIENTED_EDGE('',*,*,#145,.T.);
#1663=DIRECTION('',(0.,0.,1.));
#1664=VECTOR('',#1663,1.);
#1665=CARTESIAN_POINT('',(50.8,82.55,-25.4));
#1666=LINE('',#1665,#1664);
#1667=EDGE_CURVE('E594',#1168,#144,#1666,.T.);
#1668=ORIENTED_EDGE('',*,*,#1667,.F.);
#1669=ORIENTED_EDGE('',*,*,#1169,.F.);
#1670=EDGE_LOOP('',(#1661,#1662,#1668,#1669));
#1671=FACE_BOUND('',#1670,.T.);
#1672=ADVANCED_FACE('F1370',(#1671),#1655,.F.);
#1673=CARTESIAN_POINT('',(57.15,82.55,-25.4));
#1674=DIRECTION('',(0.,0.,1.));
#1675=DIRECTION('',(1.,0.,0.));
#1676=AXIS2_PLACEMENT_3D('',#1673,#1674,#1675);
#1677=CYLINDRICAL_SURFACE('',#1676,6.34999999999999);
#1678=ORIENTED_EDGE('',*,*,#1667,.T.);
#1679=ORIENTED_EDGE('',*,*,#169,.T.);
#1680=DIRECTION('',(0.,0.,1.));
#1681=VECTOR('',#1680,1.);
#1682=CARTESIAN_POINT('',(63.5,82.55,-25.4));
#1683=LINE('',#1682,#1681);
#1684=EDGE_CURVE('E591',#1149,#161,#1683,.T.);
#1685=ORIENTED_EDGE('',*,*,#1684,.F.);
#1686=ORIENTED_EDGE('',*,*,#1176,.F.);
#1687=EDGE_LOOP('',(#1678,#1679,#1685,#1686));
#1688=FACE_BOUND('',#1687,.T.);
#1689=ADVANCED_FACE('F1380',(#1688),#1677,.F.);
#1690=CARTESIAN_POINT('',(63.5,127.,-25.4));
#1691=DIRECTION('',(1.,0.,0.));
#1692=DIRECTION('',(0.,0.,-1.));
#1693=AXIS2_PLACEMENT_3D('',#1690,#1691,#1692);
#1694=PLANE('',#1693);
#1695=ORIENTED_EDGE('',*,*,#1684,.T.);
#1696=ORIENTED_EDGE('',*,*,#162,.T.);
#1697=DIRECTION('',(0.,0.,1.));
#1698=VECTOR('',#1697,1.);
#1699=CARTESIAN_POINT('',(63.5,127.,-25.4));
#1700=LINE('',#1699,#1698);
#1701=EDGE_CURVE('E588',#1151,#153,#1700,.T.);
#1702=ORIENTED_EDGE('',*,*,#1701,.F.);
#1703=ORIENTED_EDGE('',*,*,#1152,.F.);
#1704=EDGE_LOOP('',(#1695,#1696,#1702,#1703));
#1705=FACE_BOUND('',#1704,.T.);
#1706=ADVANCED_FACE('F1391',(#1705),#1694,.F.);
#1707=CARTESIAN_POINT('',(57.15,127.,-25.4));
#1708=DIRECTION('',(0.,0.,1.));
#1709=DIRECTION('',(1.,0.,0.));
#1710=AXIS2_PLACEMENT_3D('',#1707,#1708,#1709);
#1711=CYLINDRICAL_SURFACE('',#1710,6.34999999999999);
#1712=ORIENTED_EDGE('',*,*,#1701,.T.);
#1713=ORIENTED_EDGE('',*,*,#154,.T.);
#1714=ORIENTED_EDGE('',*,*,#1660,.F.);
#1715=ORIENTED_EDGE('',*,*,#1161,.F.);
#1716=EDGE_LOOP('',(#1712,#1713,#1714,#1715));
#1717=FACE_BOUND('',#1716,.T.);
#1718=ADVANCED_FACE('F1402',(#1717),#1711,.F.);
#1719=CARTESIAN_POINT('',(57.15,25.4,-25.4));
#1720=DIRECTION('',(0.,0.,1.));
#1721=DIRECTION('',(1.,0.,0.));
#1722=AXIS2_PLACEMENT_3D('',#1719,#1720,#1721);
#1723=CYLINDRICAL_SURFACE('',#1722,6.35);
#1724=ORIENTED_EDGE('',*,*,#133,.T.);
#1725=EDGE_LOOP('',(#1724));
#1726=FACE_BOUND('',#1725,.T.);
#1727=ORIENTED_EDGE('',*,*,#1140,.F.);
#1728=EDGE_LOOP('',(#1727));
#1729=FACE_BOUND('',#1728,.T.);
#1730=ADVANCED_FACE('F1413',(#1726,#1729),#1723,.F.);
#1731=ORIENTED_EDGE('',*,*,#697,.T.);
#1732=EDGE_CURVE('E576',#696,#883,#1700,.T.);
#1733=ORIENTED_EDGE('',*,*,#1732,.T.);
#1734=ORIENTED_EDGE('',*,*,#884,.F.);
#1735=EDGE_CURVE('E596',#694,#874,#1659,.T.);
#1736=ORIENTED_EDGE('',*,*,#1735,.F.);
#1737=EDGE_LOOP('',(#1731,#1733,#1734,#1736));
#1738=FACE_BOUND('',#1737,.T.);
#1739=ADVANCED_FACE('F1416',(#1738),#1711,.F.);
#1740=ORIENTED_EDGE('',*,*,#720,.T.);
#1741=EDGE_CURVE('E590',#713,#891,#1683,.T.);
#1742=ORIENTED_EDGE('',*,*,#1741,.T.);
#1743=ORIENTED_EDGE('',*,*,#892,.F.);
#1744=ORIENTED_EDGE('',*,*,#1732,.F.);
#1745=EDGE_LOOP('',(#1740,#1742,#1743,#1744));
#1746=FACE_BOUND('',#1745,.T.);
#1747=ADVANCED_FACE('F1405',(#1746),#1694,.F.);
#1748=ORIENTED_EDGE('',*,*,#714,.T.);
#1749=EDGE_CURVE('E593',#704,#872,#1666,.T.);
#1750=ORIENTED_EDGE('',*,*,#1749,.T.);
#1751=ORIENTED_EDGE('',*,*,#899,.F.);
#1752=ORIENTED_EDGE('',*,*,#1741,.F.);
#1753=EDGE_LOOP('',(#1748,#1750,#1751,#1752));
#1754=FACE_BOUND('',#1753,.T.);
#1755=ADVANCED_FACE('F1394',(#1754),#1677,.F.);
#1756=ORIENTED_EDGE('',*,*,#705,.T.);
#1757=ORIENTED_EDGE('',*,*,#1735,.T.);
#1758=ORIENTED_EDGE('',*,*,#875,.F.);
#1759=ORIENTED_EDGE('',*,*,#1749,.F.);
#1760=EDGE_LOOP('',(#1756,#1757,#1758,#1759));
#1761=FACE_BOUND('',#1760,.T.);
#1762=ADVANCED_FACE('F1383',(#1761),#1655,.F.);
#1763=ORIENTED_EDGE('',*,*,#684,.T.);
#1764=EDGE_LOOP('',(#1763));
#1765=FACE_BOUND('',#1764,.T.);
#1766=ORIENTED_EDGE('',*,*,#863,.F.);
#1767=EDGE_LOOP('',(#1766));
#1768=FACE_BOUND('',#1767,.T.);
#1769=ADVANCED_FACE('F1426',(#1765,#1768),#1723,.F.);
#1770=CARTESIAN_POINT('',(30.275,43.,-25.4));
#1771=DIRECTION('',(0.,-1.,0.));
#1772=DIRECTION('',(0.,0.,-1.));
#1773=AXIS2_PLACEMENT_3D('',#1770,#1771,#1772);
#1774=PLANE('',#1773);
#1775=DIRECTION('',(0.,0.,1.));
#1776=VECTOR('',#1775,1.);
#1777=CARTESIAN_POINT('',(30.275,43.,-25.4));
#1778=LINE('',#1777,#1776);
#1779=EDGE_CURVE('E490',#1114,#97,#1778,.T.);
#1780=ORIENTED_EDGE('',*,*,#1779,.T.);
#1781=ORIENTED_EDGE('',*,*,#100,.T.);
#1782=DIRECTION('',(0.,0.,1.));
#1783=VECTOR('',#1782,1.);
#1784=CARTESIAN_POINT('',(45.925,43.,-25.4));
#1785=LINE('',#1784,#1783);
#1786=EDGE_CURVE('E497',#1122,#99,#1785,.T.);
#1787=ORIENTED_EDGE('',*,*,#1786,.F.);
#1788=ORIENTED_EDGE('',*,*,#1123,.F.);
#1789=EDGE_LOOP('',(#1780,#1781,#1787,#1788));
#1790=FACE_BOUND('',#1789,.T.);
#1791=ADVANCED_FACE('F968',(#1790),#1774,.F.);
#1792=CARTESIAN_POINT('',(45.925,70.,-25.4));
#1793=DIRECTION('',(1.,0.,0.));
#1794=DIRECTION('',(0.,0.,-1.));
#1795=AXIS2_PLACEMENT_3D('',#1792,#1793,#1794);
#1796=PLANE('',#1795);
#1797=ORIENTED_EDGE('',*,*,#1786,.T.);
#1798=ORIENTED_EDGE('',*,*,#122,.T.);
#1799=DIRECTION('',(0.,0.,1.));
#1800=VECTOR('',#1799,1.);
#1801=CARTESIAN_POINT('',(45.925,70.,-25.4));
#1802=LINE('',#1801,#1800);
#1803=EDGE_CURVE('E494',#1104,#115,#1802,.T.);
#1804=ORIENTED_EDGE('',*,*,#1803,.F.);
#1805=ORIENTED_EDGE('',*,*,#1129,.F.);
#1806=EDGE_LOOP('',(#1797,#1798,#1804,#1805));
#1807=FACE_BOUND('',#1806,.T.);
#1808=ADVANCED_FACE('F1514',(#1807),#1796,.F.);
#1809=CARTESIAN_POINT('',(30.275,70.,-25.4));
#1810=DIRECTION('',(0.,1.,0.));
#1811=DIRECTION('',(0.,0.,1.));
#1812=AXIS2_PLACEMENT_3D('',#1809,#1810,#1811);
#1813=PLANE('',#1812);
#1814=ORIENTED_EDGE('',*,*,#1803,.T.);
#1815=ORIENTED_EDGE('',*,*,#116,.T.);
#1816=DIRECTION('',(0.,0.,1.));
#1817=VECTOR('',#1816,1.);
#1818=CARTESIAN_POINT('',(30.275,70.,-25.4));
#1819=LINE('',#1818,#1817);
#1820=EDGE_CURVE('E491',#1106,#107,#1819,.T.);
#1821=ORIENTED_EDGE('',*,*,#1820,.F.);
#1822=ORIENTED_EDGE('',*,*,#1107,.F.);
#1823=EDGE_LOOP('',(#1814,#1815,#1821,#1822));
#1824=FACE_BOUND('',#1823,.T.);
#1825=ADVANCED_FACE('F1158',(#1824),#1813,.F.);
#1826=CARTESIAN_POINT('',(30.275,70.,-25.4));
#1827=DIRECTION('',(-1.,0.,0.));
#1828=DIRECTION('',(0.,-1.,0.));
#1829=AXIS2_PLACEMENT_3D('',#1826,#1827,#1828);
#1830=PLANE('',#1829);
#1831=ORIENTED_EDGE('',*,*,#1820,.T.);
#1832=ORIENTED_EDGE('',*,*,#108,.T.);
#1833=ORIENTED_EDGE('',*,*,#1779,.F.);
#1834=ORIENTED_EDGE('',*,*,#1115,.F.);
#1835=EDGE_LOOP('',(#1831,#1832,#1833,#1834));
#1836=FACE_BOUND('',#1835,.T.);
#1837=ADVANCED_FACE('F1151',(#1836),#1830,.F.);
#1838=CARTESIAN_POINT('',(12.7,12.7,-25.4));
#1839=DIRECTION('',(0.,-1.,0.));
#1840=DIRECTION('',(0.,0.,-1.));
#1841=AXIS2_PLACEMENT_3D('',#1838,#1839,#1840);
#1842=PLANE('',#1841);
#1843=DIRECTION('',(0.,0.,1.));
#1844=VECTOR('',#1843,1.);
#1845=CARTESIAN_POINT('',(12.7,12.7,-25.4));
#1846=LINE('',#1845,#1844);
#1847=EDGE_CURVE('E467',#296,#63,#1846,.T.);
#1848=ORIENTED_EDGE('',*,*,#1847,.T.);
#1849=ORIENTED_EDGE('',*,*,#66,.T.);
#1850=DIRECTION('',(0.,0.,1.));
#1851=VECTOR('',#1850,1.);
#1852=CARTESIAN_POINT('',(38.1,12.7,-25.4));
#1853=LINE('',#1852,#1851);
#1854=EDGE_CURVE('E475',#1069,#65,#1853,.T.);
#1855=ORIENTED_EDGE('',*,*,#1854,.F.);
#1856=ORIENTED_EDGE('',*,*,#1070,.F.);
#1857=EDGE_LOOP('',(#1848,#1849,#1855,#1856));
#1858=FACE_BOUND('',#1857,.T.);
#1859=ADVANCED_FACE('F1147',(#1858),#1842,.F.);
#1860=CARTESIAN_POINT('',(38.1,30.3,-25.4));
#1861=DIRECTION('',(1.,0.,0.));
#1862=DIRECTION('',(0.,0.,-1.));
#1863=AXIS2_PLACEMENT_3D('',#1860,#1861,#1862);
#1864=PLANE('',#1863);
#1865=ORIENTED_EDGE('',*,*,#1854,.T.);
#1866=ORIENTED_EDGE('',*,*,#88,.T.);
#1867=DIRECTION('',(0.,0.,1.));
#1868=VECTOR('',#1867,1.);
#1869=CARTESIAN_POINT('',(38.1,30.3,-25.4));
#1870=LINE('',#1869,#1868);
#1871=EDGE_CURVE('E472',#1077,#81,#1870,.T.);
#1872=ORIENTED_EDGE('',*,*,#1871,.F.);
#1873=ORIENTED_EDGE('',*,*,#1078,.F.);
#1874=EDGE_LOOP('',(#1865,#1866,#1872,#1873));
#1875=FACE_BOUND('',#1874,.T.);
#1876=ADVANCED_FACE('F964',(#1875),#1864,.F.);
#1877=CARTESIAN_POINT('',(12.7,30.3,-25.4));
#1878=DIRECTION('',(0.,1.,0.));
#1879=DIRECTION('',(0.,0.,1.));
#1880=AXIS2_PLACEMENT_3D('',#1877,#1878,#1879);
#1881=PLANE('',#1880);
#1882=ORIENTED_EDGE('',*,*,#1871,.T.);
#1883=ORIENTED_EDGE('',*,*,#82,.T.);
#1884=DIRECTION('',(0.,0.,1.));
#1885=VECTOR('',#1884,1.);
#1886=CARTESIAN_POINT('',(12.7,30.3,-25.4));
#1887=LINE('',#1886,#1885);
#1888=EDGE_CURVE('E468',#1085,#73,#1887,.T.);
#1889=ORIENTED_EDGE('',*,*,#1888,.F.);
#1890=ORIENTED_EDGE('',*,*,#1086,.F.);
#1891=EDGE_LOOP('',(#1882,#1883,#1889,#1890));
#1892=FACE_BOUND('',#1891,.T.);
#1893=ADVANCED_FACE('F958',(#1892),#1881,.F.);
#1894=CARTESIAN_POINT('',(12.7,30.3,-25.4));
#1895=DIRECTION('',(-1.,0.,0.));
#1896=DIRECTION('',(0.,-1.,0.));
#1897=AXIS2_PLACEMENT_3D('',#1894,#1895,#1896);
#1898=PLANE('',#1897);
#1899=ORIENTED_EDGE('',*,*,#1888,.T.);
#1900=ORIENTED_EDGE('',*,*,#74,.T.);
#1901=ORIENTED_EDGE('',*,*,#1847,.F.);
#1902=ORIENTED_EDGE('',*,*,#1092,.F.);
#1903=EDGE_LOOP('',(#1899,#1900,#1901,#1902));
#1904=FACE_BOUND('',#1903,.T.);
#1905=ADVANCED_FACE('F971',(#1904),#1898,.F.);
#1906=CARTESIAN_POINT('',(12.7,82.7,-25.4));
#1907=DIRECTION('',(0.,-1.,0.));
#1908=DIRECTION('',(0.,0.,-1.));
#1909=AXIS2_PLACEMENT_3D('',#1906,#1907,#1908);
#1910=PLANE('',#1909);
#1911=DIRECTION('',(0.,0.,1.));
#1912=VECTOR('',#1911,1.);
#1913=CARTESIAN_POINT('',(12.7,82.7,-25.4));
#1914=LINE('',#1913,#1912);
#1915=EDGE_CURVE('E439',#1024,#29,#1914,.T.);
#1916=ORIENTED_EDGE('',*,*,#1915,.T.);
#1917=ORIENTED_EDGE('',*,*,#32,.T.);
#1918=DIRECTION('',(0.,0.,1.));
#1919=VECTOR('',#1918,1.);
#1920=CARTESIAN_POINT('',(38.1,82.7,-25.4));
#1921=LINE('',#1920,#1919);
#1922=EDGE_CURVE('E423',#1032,#31,#1921,.T.);
#1923=ORIENTED_EDGE('',*,*,#1922,.F.);
#1924=ORIENTED_EDGE('',*,*,#1033,.F.);
#1925=EDGE_LOOP('',(#1916,#1917,#1923,#1924));
#1926=FACE_BOUND('',#1925,.T.);
#1927=ADVANCED_FACE('F438',(#1926),#1910,.F.);
#1928=CARTESIAN_POINT('',(38.1,82.7,-25.4));
#1929=DIRECTION('',(1.,0.,0.));
#1930=DIRECTION('',(0.,0.,-1.));
#1931=AXIS2_PLACEMENT_3D('',#1928,#1929,#1930);
#1932=PLANE('',#1931);
#1933=ORIENTED_EDGE('',*,*,#1922,.T.);
#1934=ORIENTED_EDGE('',*,*,#54,.T.);
#1935=DIRECTION('',(0.,0.,1.));
#1936=VECTOR('',#1935,1.);
#1937=CARTESIAN_POINT('',(38.1,139.7,-25.4));
#1938=LINE('',#1937,#1936);
#1939=EDGE_CURVE('E453',#1040,#47,#1938,.T.);
#1940=ORIENTED_EDGE('',*,*,#1939,.F.);
#1941=ORIENTED_EDGE('',*,*,#1041,.F.);
#1942=EDGE_LOOP('',(#1933,#1934,#1940,#1941));
#1943=FACE_BOUND('',#1942,.T.);
#1944=ADVANCED_FACE('F425',(#1943),#1932,.F.);
#1945=CARTESIAN_POINT('',(12.7,139.7,-25.4));
#1946=DIRECTION('',(0.,1.,0.));
#1947=DIRECTION('',(0.,0.,1.));
#1948=AXIS2_PLACEMENT_3D('',#1945,#1946,#1947);
#1949=PLANE('',#1948);
#1950=ORIENTED_EDGE('',*,*,#1939,.T.);
#1951=ORIENTED_EDGE('',*,*,#48,.T.);
#1952=DIRECTION('',(0.,0.,1.));
#1953=VECTOR('',#1952,1.);
#1954=CARTESIAN_POINT('',(12.7,139.7,-25.4));
#1955=LINE('',#1954,#1953);
#1956=EDGE_CURVE('E449',#800,#39,#1955,.T.);
#1957=ORIENTED_EDGE('',*,*,#1956,.F.);
#1958=ORIENTED_EDGE('',*,*,#1047,.F.);
#1959=EDGE_LOOP('',(#1950,#1951,#1957,#1958));
#1960=FACE_BOUND('',#1959,.T.);
#1961=ADVANCED_FACE('F920',(#1960),#1949,.F.);
#1962=CARTESIAN_POINT('',(12.7,82.7,-25.4));
#1963=DIRECTION('',(-1.,0.,0.));
#1964=DIRECTION('',(0.,0.,1.));
#1965=AXIS2_PLACEMENT_3D('',#1962,#1963,#1964);
#1966=PLANE('',#1965);
#1967=ORIENTED_EDGE('',*,*,#1956,.T.);
#1968=ORIENTED_EDGE('',*,*,#40,.T.);
#1969=ORIENTED_EDGE('',*,*,#1915,.F.);
#1970=ORIENTED_EDGE('',*,*,#1025,.F.);
#1971=EDGE_LOOP('',(#1967,#1968,#1969,#1970));
#1972=FACE_BOUND('',#1971,.T.);
#1973=ADVANCED_FACE('F917',(#1972),#1966,.F.);
#1974=ORIENTED_EDGE('',*,*,#651,.T.);
#1975=EDGE_CURVE('E458',#650,#837,#1819,.T.);
#1976=ORIENTED_EDGE('',*,*,#1975,.T.);
#1977=ORIENTED_EDGE('',*,*,#838,.F.);
#1978=EDGE_CURVE('E499',#648,#829,#1778,.T.);
#1979=ORIENTED_EDGE('',*,*,#1978,.F.);
#1980=EDGE_LOOP('',(#1974,#1976,#1977,#1979));
#1981=FACE_BOUND('',#1980,.T.);
#1982=ADVANCED_FACE('F1161',(#1981),#1830,.F.);
#1983=ORIENTED_EDGE('',*,*,#673,.T.);
#1984=EDGE_CURVE('E493',#666,#845,#1802,.T.);
#1985=ORIENTED_EDGE('',*,*,#1984,.T.);
#1986=ORIENTED_EDGE('',*,*,#846,.F.);
#1987=ORIENTED_EDGE('',*,*,#1975,.F.);
#1988=EDGE_LOOP('',(#1983,#1985,#1986,#1987));
#1989=FACE_BOUND('',#1988,.T.);
#1990=ADVANCED_FACE('F1533',(#1989),#1813,.F.);
#1991=ORIENTED_EDGE('',*,*,#667,.T.);
#1992=EDGE_CURVE('E496',#658,#827,#1785,.T.);
#1993=ORIENTED_EDGE('',*,*,#1992,.T.);
#1994=ORIENTED_EDGE('',*,*,#852,.F.);
#1995=ORIENTED_EDGE('',*,*,#1984,.F.);
#1996=EDGE_LOOP('',(#1991,#1993,#1994,#1995));
#1997=FACE_BOUND('',#1996,.T.);
#1998=ADVANCED_FACE('F965',(#1997),#1796,.F.);
#1999=ORIENTED_EDGE('',*,*,#659,.T.);
#2000=ORIENTED_EDGE('',*,*,#1978,.T.);
#2001=ORIENTED_EDGE('',*,*,#830,.F.);
#2002=ORIENTED_EDGE('',*,*,#1992,.F.);
#2003=EDGE_LOOP('',(#1999,#2000,#2001,#2002));
#2004=FACE_BOUND('',#2003,.T.);
#2005=ADVANCED_FACE('F956',(#2004),#1774,.F.);
#2006=ORIENTED_EDGE('',*,*,#639,.T.);
#2007=EDGE_CURVE('E471',#632,#945,#1870,.T.);
#2008=ORIENTED_EDGE('',*,*,#2007,.T.);
#2009=ORIENTED_EDGE('',*,*,#946,.F.);
#2010=EDGE_CURVE('E470',#616,#937,#1887,.T.);
#2011=ORIENTED_EDGE('',*,*,#2010,.F.);
#2012=EDGE_LOOP('',(#2006,#2008,#2009,#2011));
#2013=FACE_BOUND('',#2012,.T.);
#2014=ADVANCED_FACE('F954',(#2013),#1881,.F.);
#2015=ORIENTED_EDGE('',*,*,#633,.T.);
#2016=EDGE_CURVE('E474',#624,#953,#1853,.T.);
#2017=ORIENTED_EDGE('',*,*,#2016,.T.);
#2018=ORIENTED_EDGE('',*,*,#954,.F.);
#2019=ORIENTED_EDGE('',*,*,#2007,.F.);
#2020=EDGE_LOOP('',(#2015,#2017,#2018,#2019));
#2021=FACE_BOUND('',#2020,.T.);
#2022=ADVANCED_FACE('F946',(#2021),#1864,.F.);
#2023=ORIENTED_EDGE('',*,*,#625,.T.);
#2024=EDGE_CURVE('E477',#614,#288,#1846,.T.);
#2025=ORIENTED_EDGE('',*,*,#2024,.T.);
#2026=ORIENTED_EDGE('',*,*,#960,.F.);
#2027=ORIENTED_EDGE('',*,*,#2016,.F.);
#2028=EDGE_LOOP('',(#2023,#2025,#2026,#2027));
#2029=FACE_BOUND('',#2028,.T.);
#2030=ADVANCED_FACE('F944',(#2029),#1842,.F.);
#2031=ORIENTED_EDGE('',*,*,#617,.T.);
#2032=ORIENTED_EDGE('',*,*,#2010,.T.);
#2033=ORIENTED_EDGE('',*,*,#938,.F.);
#2034=ORIENTED_EDGE('',*,*,#2024,.F.);
#2035=EDGE_LOOP('',(#2031,#2032,#2033,#2034));
#2036=FACE_BOUND('',#2035,.T.);
#2037=ADVANCED_FACE('F925',(#2036),#1898,.F.);
#2038=ORIENTED_EDGE('',*,*,#605,.T.);
#2039=EDGE_CURVE('E452',#598,#981,#1938,.T.);
#2040=ORIENTED_EDGE('',*,*,#2039,.T.);
#2041=ORIENTED_EDGE('',*,*,#982,.F.);
#2042=EDGE_CURVE('E451',#582,#808,#1955,.T.);
#2043=ORIENTED_EDGE('',*,*,#2042,.F.);
#2044=EDGE_LOOP('',(#2038,#2040,#2041,#2043));
#2045=FACE_BOUND('',#2044,.T.);
#2046=ADVANCED_FACE('F1114',(#2045),#1949,.F.);
#2047=ORIENTED_EDGE('',*,*,#599,.T.);
#2048=EDGE_CURVE('E433',#590,#908,#1921,.T.);
#2049=ORIENTED_EDGE('',*,*,#2048,.T.);
#2050=ORIENTED_EDGE('',*,*,#988,.F.);
#2051=ORIENTED_EDGE('',*,*,#2039,.F.);
#2052=EDGE_LOOP('',(#2047,#2049,#2050,#2051));
#2053=FACE_BOUND('',#2052,.T.);
#2054=ADVANCED_FACE('F1121',(#2053),#1932,.F.);
#2055=ORIENTED_EDGE('',*,*,#591,.T.);
#2056=EDGE_CURVE('E434',#580,#910,#1914,.T.);
#2057=ORIENTED_EDGE('',*,*,#2056,.T.);
#2058=ORIENTED_EDGE('',*,*,#911,.F.);
#2059=ORIENTED_EDGE('',*,*,#2048,.F.);
#2060=EDGE_LOOP('',(#2055,#2057,#2058,#2059));
#2061=FACE_BOUND('',#2060,.T.);
#2062=ADVANCED_FACE('F1123',(#2061),#1910,.F.);
#2063=ORIENTED_EDGE('',*,*,#583,.T.);
#2064=ORIENTED_EDGE('',*,*,#2042,.T.);
#2065=ORIENTED_EDGE('',*,*,#917,.F.);
#2066=ORIENTED_EDGE('',*,*,#2056,.F.);
#2067=EDGE_LOOP('',(#2063,#2064,#2065,#2066));
#2068=FACE_BOUND('',#2067,.T.);
#2069=ADVANCED_FACE('F1109',(#2068),#1966,.F.);
#2070=CLOSED_SHELL('',(#275,#315,#355,#420,#460,#518,#569,#798,#816,#992,#1007,#1180,#1192,
#1204,#1211,#1218,#1249,#1273,#1297,#1314,#1326,#1357,#1381,#1405,#1422,#1434,#1465,#1489,#1513,
#1530,#1542,#1573,#1597,#1621,#1638,#1650,#1672,#1689,#1706,#1718,#1730,#1739,#1747,#1755,#1762,
#1769,#1791,#1808,#1825,#1837,#1859,#1876,#1893,#1905,#1927,#1944,#1961,#1973,#1982,#1990,#1998,
#2005,#2014,#2022,#2030,#2037,#2046,#2054,#2062,#2069));
#2071=MANIFOLD_SOLID_BREP('B2',#2070);
#2072=ADVANCED_BREP_SHAPE_REPRESENTATION('',(#18,#2071),#14);
#2073=SHAPE_DEFINITION_REPRESENTATION(#9,#2072);
ENDSEC;
END-ISO-10303-21;
